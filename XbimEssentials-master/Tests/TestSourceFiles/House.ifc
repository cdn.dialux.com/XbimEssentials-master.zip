Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: House
Time: 2016-02-03T15:59:13

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 3

# IfcBuildingStorey (3)
Name | Elevation (mm)
Уровень 1 | -600
Уровень 2 | 2850
Кровля | 3350

# IfcSpace (13)
InteriorOrExteriorSpace: INTERNAL
Name | In | LongName | NominalHeight (mm) | GrossFloorArea | GrossVolume
3 | Уровень 1 | Студия-гостиная | 3150 | 44190000 | 139198500000
1 | Уровень 1 | Прихожая | 3150 | 7560000 | 23814000000
2 | Уровень 1 | Холл | 3150 | 7835975 | 24683322500
4 | Уровень 1 | Коридор | 3600 | 2152503 | 7749009526
6 | Уровень 1 | С/У | 3600 | 4407505 | 15867019506
5 | Уровень 1 | Тамбур | 3600 | 6765000 | 24354000000
7 | Уровень 1 | Гараж | 3000 | 41310000 | 123930000000
9 | Уровень 2 | Комната | 2400 | 14828736 | 35588967059
8 | Уровень 2 | Комната | 2400 | 14905164 | 35772392834
13 | Уровень 2 | Комната | 3000 | 13860000 | 41580000000
10 | Уровень 2 | С/У | 3600 | 7560000 | 27216000000
12 | Уровень 2 | Большая комната | 3600 | 41310000 | 148716000000
11 | Уровень 2 | Коридор | 3600 | 3999502 | 14398208072

# IfcColumn: Колонна - прямоугольная: 200x200 мм (5)
In: Уровень 1
Type - ElementType: Колонна - прямоугольная: 200x200 мм; PredefinedType: COLUMN
Material: Бетон
IfcElementQuantity - CrossSectionArea: 40000
Name (Колонна - прямоугольная:...) | NominalLength (mm) | NetVolume
3 x  200x200 мм | 3000 | 112664443
2 x  200x200 мм | 3100 | 118896207

# IfcDoor: Однопольная подъемная
In: Уровень 1
Type - OperationType: ROLLINGUP; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Panel Properties - PanelOperation: ROLLINGUP; PanelWidth: 1; PanelPosition: MIDDLE
OverallHeight: 2500 mm; OverallWidth: 3000 mm

# IfcDoor: Однопольная распашная (глухое) (7)
Type - OperationType: SINGLE_SWING_LEFT; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Panel Properties - PanelDepth: 50 mm; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: LEFT
Name | In | OverallHeight (mm) | OverallWidth (mm)
 | Уровень 1 | 2450 | 900
4 x  | Уровень 1 | 2100 | 900
 | Уровень 2 | 2100 | 900
 | Уровень 2 | 2100 | 800

# IfcDoor: Однопольная распашная (глухое)
In: Уровень 1
Type - OperationType: SINGLE_SWING_RIGHT; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Lining Properties - TransomThickness: 0 mm; TransomOffset: 2020 mm
Type - Door Panel Properties - PanelDepth: 50 mm; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: RIGHT
OverallHeight: 2600 mm; OverallWidth: 1000 mm

# IfcDoor: Однопольная распашная (глухое) (4)
Type - OperationType: SINGLE_SWING_RIGHT; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Panel Properties - PanelDepth: 50 mm; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: RIGHT
Name | In | OverallHeight (mm) | OverallWidth (mm)
 | Уровень 1 | 2450 | 1000
 | Уровень 1 | 2400 | 1000
 | Уровень 2 | 2100 | 900
 | Уровень 2 | 2100 | 800

# IfcDoor: Однопольная распашная (остекленное)
In: Уровень 2
Type - OperationType: SINGLE_SWING_LEFT; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Panel Properties - PanelDepth: 50 mm; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: LEFT
OverallHeight: 2100 mm; OverallWidth: 900 mm

# IfcDoor: Однопольная распашная (остекленное)
In: Уровень 1
Type - OperationType: SINGLE_SWING_RIGHT; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Lining Properties - TransomThickness: 0 mm; TransomOffset: 2220 mm
Type - Door Panel Properties - PanelDepth: 50 mm; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: RIGHT
OverallHeight: 2600 mm; OverallWidth: 800 mm

# IfcDoor: Однопольная распашная (остекленное)
In: Уровень 2
Type - OperationType: SINGLE_SWING_RIGHT; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Panel Properties - PanelDepth: 50 mm; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: RIGHT
OverallHeight: 2100 mm; OverallWidth: 900 mm

# IfcDoor: Четырехпольная откатная (остеклённое) (3)
Type - OperationType: USERDEFINED; ParameterTakesPrecedence: no; Sizeable: no
Type - Door Panel Properties - PanelWidth: 0.249545; PanelDepth: 50 mm; PanelOperation: SLIDING
OverallHeight: 2100 mm; OverallWidth: 1400 mm
Name | In
 | Уровень 1
2 x  | Уровень 2

# IfcRailing (19)
Material: Материал по умолчанию
Pset_RailingCommon - Height: 1000 mm
Name | In
9 x  | Уровень 1
10 x  | Уровень 2

# IfcRoof (4)
In: Кровля
ShapeType: FREEFORM; Material: Материал по умолчанию 200 mm
Name | TotalSurfaceArea
 | 11539750
 | 161620729
 | 89760458
 | 23497331

# IfcSlab (13)
PredefinedType: FLOOR
Name | In | Material | NominalWidth (mm) | NetArea | NetVolume
 | Уровень 1 | Деревянный пол 50 mm, Железобетон 100 mm | 150 | 48060000 | 7209000000
2 x  | Уровень 1 | Деревянный пол 50 mm, Железобетон 550 mm | 600 | 900000 | 540000000
 | Уровень 1 | Деревянный пол 50 mm, Железобетон 550 mm | 600 | 31850000 | 18323239291
 | Уровень 2 | Деревянный пол 50 mm, Железобетон 250 mm | 300 | 45900000 | 13770000000
 | Уровень 2 | Материал по умолчанию 200 mm | 200 | 997591 | 199518251
 | Уровень 2 | Деревянный пол 50 mm, Железобетон 250 mm | 300 | 50380000 | 15114000000
 | Уровень 2 | Деревянный пол 50 mm, Железобетон 250 mm | 300 | 7560000 | 2268000000
 | Уровень 2 | Материал по умолчанию 200 mm | 200 | 3999502 | 799900448
 | Уровень 2 | Деревянный пол 50 mm, Железобетон 250 mm | 300 | 16560000 | 4968000000
 | Уровень 2 | Деревянный пол 50 mm, Железобетон 150 mm | 200 | 4300000 | 860000000
 | Уровень 1 | Деревянный пол 50 mm, Железобетон 100 mm | 150 | 19110000 | 2866500000
 | Уровень 1 | Деревянный пол 50 mm, Железобетон 550 mm | 600 | 69290000 | 41574000000

# IfcStair (5)
ShapeType: USERDEFINED
Name | In | NumberOfRiser = NumberOfTreads | RiserHeight (mm) | TreadLength (mm)
 | Уровень 1 | 3 | 200 | 300
 | Уровень 1 | 3 | 150 | 282.787
 | Уровень 1 | 3 | 200 | 400
 | Уровень 1 | 19 | 150 | 289.474
 | Уровень 2 | 4 | 150 | 300.002

# IfcStairFlight (5)
Material: Материал по умолчанию
Name | In | NumberOfRiser = NumberOfTreads = Pset_StairFlightCommon, NumberOfRiser = Pset_StairFlightCommon, NumberOfTreads | RiserHeight (mm) = Pset_StairFlightCommon, RiserHeight (mm) | TreadLength (mm) = Pset_StairFlightCommon, TreadLength (mm)
 | Уровень 1 | 3 | 200 | 300
 | Уровень 1 | 3 | 150 | 282.787
 | Уровень 1 | 3 | 200 | 400
 | Уровень 1 | 19 | 150 | 289.474
 | Уровень 2 | 4 | 150 | 300.002

# IfcWallStandardCase: Стена: 100мм (2)
In: Уровень 1
Material: Гипс 100 mm
IfcElementQuantity - NominalHeight: 3700 mm; NominalWidth: 100 mm
PS_RENGA_WallBaselineOffset - BaselineOffset: 1
Name (Стена:...) | NominalLength (mm) | NetVolume
 100мм | 3300 | 999000000
 100мм | 2050.01 | 549001814

# IfcWallStandardCase: Стена: 200мм (8)
Material: Гипс 200 mm
IfcElementQuantity - NominalWidth: 200 mm
Name (Стена:...) | In | NominalHeight (mm) | NominalLength (mm) | NetVolume | BaselineOffset
 200мм | Уровень 1 | 3450 | 4200 | 2394000000 | 0
 200мм | Уровень 1 | 2850 | 4200 | 1914000000 | 2
 200мм | Уровень 2 | 7000 | 4200 | 4104472245 | 0
 200мм | Уровень 2 | 7000 | 4200 | 3140412684 | 0
 200мм | Уровень 2 | 7000 | 4196.92 | 3503526269 | 1
 200мм | Уровень 2 | 7000 | 699.708 | 456915105 | 0
 200мм | Уровень 2 | 7000 | 2200 | 986917380 | 0
 200мм | Уровень 2 | 7000 | 706.149 | 472975109 | 0

# IfcWallStandardCase: Стена: 300мм (3)
Material: Бетон 300 mm
IfcElementQuantity - NominalWidth: 300 mm
PS_RENGA_WallBaselineOffset - BaselineOffset: 0
Name (Стена:...) | In | NominalHeight (mm) | NominalLength (mm) | NetVolume
 300мм | Уровень 1 | 3300 | 2400 | 2376000000
 300мм | Уровень 2 | 7000 | 7700 | 9111446160
 300мм | Уровень 1 | 2850 | 5300 | 3649500000

# IfcWallStandardCase: Стена: 400мм (33)
IfcElementQuantity - NominalWidth: 400 mm
Name (Стена:...) | In | Material | NominalHeight (mm) | NominalLength (mm) | NetVolume | BaselineOffset
 400мм | Уровень 1 | Бетон 400 mm | 3300 | 8500 | 9570000000 | 0
 400мм | Уровень 1 | Бетон 400 mm | 3300 | 5400 | 3780000000 | 0
 400мм | Уровень 1 | Бетон 400 mm | 3300 | 5200 | 5290000000 | 2
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 5500 | 4758000000 | 0
2 x  400мм | Уровень 1 | Бетон 400 mm | 2850 | 2850 | 3249000000 | 0
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 1200 | 936000691 | 0
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 2800 | 1895999260 | 0
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 1200 | 936000049 | 0
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 5300 | 3930000000 | 0
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 4200 | 2500000000 | 2
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 1000 | 1140000000 | 0
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 1000 | 1086000000 | 0
 400мм | Уровень 1 | Бетон 400 mm | 3300 | 1300 | 1716000000 | 2
 400мм | Уровень 1 | Бетон 400 mm | 3300 | 4600 | 4899750000 | 2
 400мм | Уровень 1 | Бетон 400 mm | 3300 | 1300 | 1650750000 | 2
 400мм | Уровень 1 | Бетон 400 mm | 3300 | 2400 | 2280000000 | 0
 400мм | Уровень 1 | Бетон 400 mm | 2850 | 5300 | 5724000000 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 8500 | 6379324420 | 0
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 5400 | 1433540645 | 0
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 8500 | 12681324420 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 5500 | 5634777254 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 1000 | 1167210298 | 0
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 4200 | 5717562333 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 1000 | 432710298 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 5300 | 5127442896 | 0
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 4600 | 5335848286 | 0
2 x  400мм | Уровень 2 | Материал по умолчанию 400 mm | 600 | 1000 | 120000000 | 2
 400мм | Уровень 2 | Материал по умолчанию 400 mm | 600 | 2800 | 336000000 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 1300 | 1258791164 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 5200 | 1384590249 | 2
 400мм | Уровень 2 | Бетон 400 mm | 7000 | 9000 | 13750589044 | 2

# IfcWindow: Двустворчатое (3)
In: Уровень 2
Type - OperationType: DOUBLE_PANEL_VERTICAL; ParameterTakesPrecedence: no; Sizeable: no
Type - Window Lining Properties - LiningDepth: 50 mm; LiningThickness: 50 mm; MullionThickness: 50 mm; FirstMullionOffset: 0.5
Type - Window Panel Properties - PanelPosition: LEFT
Name | OverallHeight (mm) | OverallWidth (mm)
2 x  | 1600 | 1400
 | 1400 | 1600

# IfcWindow: Двустворчатое с фрамугой и разными створками
In: Уровень 1
Type - OperationType: TRIPLE_PANEL_TOP; ParameterTakesPrecedence: no; Sizeable: no
Type - Window Lining Properties - LiningDepth: 50 mm; LiningThickness: 50 mm; TransomThickness: 50 mm; MullionThickness: 50 mm; FirstTransomOffset: 0.82; FirstMullionOffset: 0.38
Type - Window Panel Properties - PanelPosition: LEFT
OverallHeight: 1600 mm; OverallWidth: 1400 mm

# IfcWindow: Одностворчатое (12)
Type - OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no
Type - Window Lining Properties - LiningDepth: 50 mm; LiningThickness: 50 mm
Type - Window Panel Properties - PanelPosition: MIDDLE
Name | In | OverallHeight (mm) | OverallWidth (mm)
5 x  | Уровень 1 | 600 | 1200
2 x  | Уровень 1 | 600 | 600
2 x  | Уровень 2 | 2100 | 300
2 x  | Уровень 2 | 1400 | 600
 | Уровень 2 | 600 | 1200

# IfcWindow: Одностворчатое с фрамугой (5)
In: Уровень 1
Type - OperationType: DOUBLE_PANEL_HORIZONTAL; ParameterTakesPrecedence: no; Sizeable: no
Type - Window Lining Properties - LiningDepth: 50 mm; LiningThickness: 50 mm; TransomThickness: 50 mm; FirstTransomOffset: 0.8
Type - Window Panel Properties - PanelPosition: BOTTOM
OverallWidth: 600 mm
Name | OverallHeight (mm)
2 x  | 1800
 | 1600
2 x  | 2600

# IfcWindow: Трехстворчатое с фрамугой (2)
In: Уровень 1
Type - OperationType: USERDEFINED; ParameterTakesPrecedence: no; Sizeable: no
Type - Window Lining Properties - LiningDepth: 50 mm; LiningThickness: 50 mm
OverallHeight: 1800 mm
Name | OverallWidth (mm)
 | 2100
 | 1800
