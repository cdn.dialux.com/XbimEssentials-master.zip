Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Project Number
Time: 2015-09-30T13:29:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140903_1530(x64) - Exporter 17.0.416.0 - Alternate UI 15.5.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 30 13:29:00 2015 * Host: C13300493 * Database: C:\Users\mxfm2\AppData\Local\Temp\{7088F069-48B3-4275-BFA0-0FBFE311EC57}\ifc * Database version: 5507 * Database creation date: Wed Sep 30 13:28:53 2015 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Sep 30 13:28:53 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 30 13:28:53 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 2
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey (2)
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Type Name: Circle Head - Project Datum
Other - Category: Levels; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum; Family Name: Level
Constraints - Elevation Base: Project Base Point
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
Ground Floor | Ground Floor | 0
Roof | Roof | 2500

# IfcSpace (4)
PredefinedType: SPACE
Pset_SpaceCommon - IsExternal: no
Constraints - Base Offset: 0 mm; Upper Limit: Level: Roof
Dimensions - Computation Height: 0 mm
Energy Analysis - Actual Lighting Load: 0 W; Actual Lighting Load per area: 0; Actual Power Load: 0 W; Actual Power Load per area: 0; Area per Person: 28.5714 m2; Base Lighting Load on: <Default>; Base Power Load on: <Default>; Heat Load Values: <Default>; Latent Heat Gain per person: 630.918; Lighting Load Units: Power Density; Number of People: 0; Plenum Lighting Contribution: 0.2; Power Load Units: Power Density; Sensible Heat Gain per person: 788.648; Specified Lighting Load: 0 W; Specified Lighting Load per area: 10.7639; Specified Power Load: 0 W; Specified Power Load per area: 13.9931; Total Heat Gain per person: 1419.57
Other - Category: Rooms; Phase Id: New Construction
Phasing - Phase: New Construction
Name | In | LongName = Name | Reference | NetFloorArea (m2) = GrossFloorArea (m2) = Area (m2) | Height (mm) = Unbounded Height (mm) | GrossPerimeter (mm) = Perimeter (mm) | GrossVolume (m3) | Level | Limit Offset (mm) | Number
1 - Living room | Ground Floor | Living room | Living room 1 - Living room | 51.9948 | 2500 | 29925 | 129987 | Level: Ground Floor | 0 | 1 - Living room
2 - Bedroom | Ground Floor | Bedroom | Bedroom 2 - Bedroom | 15.4168 | 2500 | 15830 | 38542 | Level: Ground Floor | 0 | 2 - Bedroom
3 - Entrance hall | Ground Floor | Entrance hall | Entrance hall 3 - Entrance hall | 8.69351 | 2500 | 12810 | 21733.8 | Level: Ground Floor | 0 | 3 - Entrance hall
4 - Roof | Roof | Roof | Roof 4 - Roof | 76.4655 | 1000 | 38935.4 | 76465.5 | Roof | 1000 | 4 - Roof

# IfcCovering: Compound Ceiling:Plain (3)
In: Ground Floor
PredefinedType: CEILING; Material: Metal Stud Layer 45 mm, Gypsum Wall Board 12 mm
Pset_CoveringCommon - IsExternal: no; Reference: Plain; ThermalTransmittance: 0.549915 kg/K/s3
Constraints - Room Bounding: yes; Height Offset From Level: 2200 mm; Level: Level: Ground Floor
Other - Category: Ceilings; Family: Compound Ceiling: Plain; Family and Type: Compound Ceiling: Plain; Type: Compound Ceiling: Plain; Type Id: Compound Ceiling: Plain; Family Name: Compound Ceiling
Phasing - Phase Created: New Construction
Analytical Properties - Roughness: 3; Absorptance: 0.7; Heat Transfer Coefficient (U): 0.549915; Thermal mass: 11142.2; Thermal Resistance (R): 1.81846
Construction - Thickness: 57 mm
Graphics - Coarse Scale Fill Color: 0
Identity Data - Keynote: K40; Type Name: Plain
Name (Compound Ceiling:Plain:...) | GrossCeilingArea (m2) = Area (m2) | Perimeter (mm) | Volume (m3)
286319 | 51.9948 | 29925 | 2.96371
286329 | 15.4168 | 15830 | 0.878757
286337 | 8.69351 | 12810 | 0.49553

# IfcCurtainWall: Curtain Wall:Curtain_Wall-Exterior_Glazing (2)
In: Ground Floor
Type - Construction - Function: Exterior; Automatically Embed: no; Join Condition: Horizontal Grid Continuous
Type - Horizontal Grid - Adjust for Mullion Size: no; Layout: Fixed Distance; Spacing: 4000 mm
Type - Horizontal Mullions - Border 1 Type: Rectangular Mullion: 30mm_Square; Border 2 Type: Rectangular Mullion: 30mm_Square; Interior Type: Rectangular Mullion: 30mm_Square
Type - Identity Data - Keynote: H11; Type Name: Curtain_Wall-Exterior_Glazing
Type - Other - Category: Walls; Family Name: Curtain Wall
Type - Vertical Grid - Adjust for Mullion Size: no; Layout: Minimum Spacing; Spacing: 1500 mm
Type - Vertical Mullions - Border 1 Type: Rectangular Mullion: 30mm_Square; Border 2 Type: Rectangular Mullion: 30mm_Square; Interior Type: Rectangular Mullion: 30mm_Square
Pset_CurtainWallCommon - IsExternal: yes; Reference: Curtain_Wall-Exterior_Glazing
Constraints - Base Offset: 0 mm; Base Constraint: Level: Ground Floor; Base is Attached: no; Related to Mass: no; Room Bounding: yes; Top is Attached: yes; Top Offset: 0 mm; Unconnected Height: 8000 mm
Horizontal Grid - Angle: 0 deg; Offset: 0 mm; Justification: Beginning; Number: 1
Other - Family: Curtain Wall: Curtain_Wall-Exterior_Glazing; Family and Type: Curtain Wall: Curtain_Wall-Exterior_Glazing; Type: Curtain Wall: Curtain_Wall-Exterior_Glazing; Type Id: Curtain Wall: Curtain_Wall-Exterior_Glazing
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Vertical Grid - Angle: 0 deg; Offset: 0 mm; Justification: Beginning; Number: 2
Name (Curtain Wall:Curtain_Wall-Exterior_Glazing:...) | Area (m2) | Length (mm)
285582 | 17.6059 | 5800
285684 | 13.4814 | 4900

# IfcDoor: 1810x2110mm, Doors_ExtDbl_Flush:1810x2110mm:285860
In: Ground Floor
Type - PredefinedType: DOOR; OperationType: DOUBLE_DOOR_SINGLE_SWING; ParameterTakesPrecedence: no; Material: Door - Handle, Door - Frame/Mullion, Door - Panel
Type - Doors_ExtDbl_Flush:1810x2110mm:285860 - PanelOperation: SWINGING
Type - Analytical Properties - Analytic Construction: <None>
Type - Constraints - Door Panel Height: 2000 mm; Door Panel Width: 852 mm
Type - Construction - Function: Exterior; Wall Closure: By host; Wrap Layers (Ext) from Ext: 102.5 mm; Wrap Layers (Int) from Ext: 177.5 mm
Type - Dimensions - Cavity Closer Depth: 85 mm; Cavity Closer Offset from Ext: 102.5 mm; Cavity Closer Width: 50 mm; Cill Extension: 25 mm; Cill Projection: 30 mm; Cill Thickness: 54.5 mm; Door Panel Thickness: 44 mm; FrameOffset - External: 25 mm; Handle X Distance: 75 mm; Handle Z Distance: 1050 mm; Height: 2110 mm; Rough Height: 2110 mm; Rough Width: 1810 mm; Structural Tolerance: 6.5 mm; Thickness: 44 mm; Tolerance: 3 mm; Undercut: 4 mm; Width: 1810 mm
Type - Graphics - Vis - Cavity Closers: yes; Vis - Ironmongery: yes
Type - Identity Data - Keynote: L20; Type Comments: External Double; Type Mark: 44; Type Name: 1810x2110mm
Type - Materials and Finishes - Material Door: Door - Panel; Material Frame: Door - Frame/Mullion; Material Ironmongery: Door - Handle
Type - Other - Category: Doors; Family Name: Doors_ExtDbl_Flush; FrameDepth: 89 mm; FrameWidth: 42 mm; O/A Frame Width: 64 mm
OverallHeight: 2110 mm; OverallWidth: 1810 mm
Pset_DoorCommon - IsExternal: yes; Reference: 1810x2110mm
BaseQuantities - Height: 2110 mm; Width: 1810 mm; Area: 4.94621 m2
Constraints - Level: Level: Ground Floor; Sill Height: 0 mm
Dimensions - Area: 4.94621 m2; Volume: 0.19382 m3
Identity Data - Mark: 1
Other - Family: Doors_ExtDbl_Flush: 1810x2110mm; Family and Type: Doors_ExtDbl_Flush: 1810x2110mm; Head Height: 2110 mm; Host Id: Basic Wall: Wall-Ext_102Bwk-75Ins-100LBlk-12P; Type: Doors_ExtDbl_Flush: 1810x2110mm; Type Id: Doors_ExtDbl_Flush: 1810x2110mm
Phasing - Phase Created: New Construction

# IfcDoor: 810x2110mm, Doors_IntSgl:810x2110mm:285996
In: Ground Floor
Type - PredefinedType: DOOR; OperationType: SINGLE_SWING_RIGHT; ParameterTakesPrecedence: no; Material: Door - Handle, Door - Panel, Door - Architrave, Door - Frame/Mullion (1)
Type - Analytical Properties - Analytic Construction: Metal; Heat Transfer Coefficient (U): 3.7021; Solar Heat Gain Coefficient: 0; Thermal Resistance (R): 0.270117; Visual Light Transmittance: 0
Type - Constraints - Door Panel Height: 2060 mm; Door Panel Width: 726 mm
Type - Construction - Function: Interior; Wall Closure: By host
Type - Dimensions - Architrave Setback: 5 mm; Door Panel Offset: 0 mm; Door Panel Thickness: 38 mm; Handle X Distance: 75 mm; Handle Z Distance: 900 mm; Height: 2110 mm; Height to Top Lock Rail: 1000 mm; Rough Height: 2110 mm; Rough Width: 810 mm; StopDepth: 32 mm; Stop Thickness: 19 mm; Structural Tolerance: 8 mm; Thickness: 38 mm; Tolerance: 2 mm; UnderCut: 8 mm; Width: 810 mm
Type - Graphics - Vis - Ironmongery: yes
Type - Identity Data - Description: Internal Single Door; Keynote: L20; Manufacturer: Revit; Type Comments: Internal Single; Type Mark: 42; Type Name: 810x2110mm
Type - Materials and Finishes - Material Architrave: Door - Architrave; Material Door: Door - Panel; Material Frame: Door - Frame/Mullion (1); Material Ironmongery: Door - Handle
Type - Other - Category: Doors; Family Name: Doors_IntSgl; Frame Thickness: 32 mm
Type - Doors_IntSgl:810x2110mm:285996 - PanelOperation: SWINGING
OverallHeight: 2110 mm; OverallWidth: 810 mm
Pset_DoorCommon - IsExternal: no; Reference: 810x2110mm; ThermalTransmittance: 3.7021 kg/K/s3
Pset_ManufacturerTypeInformation - Manufacturer: Revit
BaseQuantities - Height: 2110 mm; Width: 810 mm; Area: 2.27348 m2
Constraints - Level: Level: Ground Floor; Sill Height: 0 mm
Dimensions - Area: 2.27348 m2; Volume: 0.0756413 m3
Identity Data - Mark: 3
Other - Family: Doors_IntSgl: 810x2110mm; Family and Type: Doors_IntSgl: 810x2110mm; Host Id: Basic Wall: Wall-Partn_12P-70MStd-12P; Type: Doors_IntSgl: 810x2110mm; Type Id: Doors_IntSgl: 810x2110mm; Head Height: 2110 mm
Phasing - Phase Created: New Construction

# IfcDoor: 810x2110mm, Doors_IntSgl:810x2110mm:285959
In: Ground Floor
Type - PredefinedType: DOOR; OperationType: SINGLE_SWING_RIGHT; ParameterTakesPrecedence: no; Material: Door - Handle, Door - Panel, Door - Architrave, Door - Frame/Mullion (1)
Type - Doors_IntSgl:810x2110mm:285959 - PanelOperation: SWINGING
Type - Analytical Properties - Analytic Construction: Metal; Heat Transfer Coefficient (U): 3.7021; Solar Heat Gain Coefficient: 0; Thermal Resistance (R): 0.270117; Visual Light Transmittance: 0
Type - Constraints - Door Panel Height: 2060 mm; Door Panel Width: 726 mm
Type - Construction - Function: Interior; Wall Closure: By host
Type - Dimensions - Architrave Setback: 5 mm; Door Panel Offset: 0 mm; Door Panel Thickness: 38 mm; Handle X Distance: 75 mm; Handle Z Distance: 900 mm; Height: 2110 mm; Height to Top Lock Rail: 1000 mm; Rough Height: 2110 mm; Rough Width: 810 mm; StopDepth: 32 mm; Stop Thickness: 19 mm; Structural Tolerance: 8 mm; Thickness: 38 mm; Tolerance: 2 mm; UnderCut: 8 mm; Width: 810 mm
Type - Graphics - Vis - Ironmongery: yes
Type - Identity Data - Description: Internal Single Door; Keynote: L20; Manufacturer: Revit; Type Comments: Internal Single; Type Mark: 42; Type Name: 810x2110mm
Type - Materials and Finishes - Material Architrave: Door - Architrave; Material Door: Door - Panel; Material Frame: Door - Frame/Mullion (1); Material Ironmongery: Door - Handle
Type - Other - Category: Doors; Family Name: Doors_IntSgl; Frame Thickness: 32 mm
OverallHeight: 2110 mm; OverallWidth: 810 mm
Pset_DoorCommon - IsExternal: no; Reference: 810x2110mm; ThermalTransmittance: 3.7021 kg/K/s3
Pset_ManufacturerTypeInformation - Manufacturer: Revit
BaseQuantities - Height: 2110 mm; Width: 810 mm; Area: 2.27348 m2
Constraints - Level: Level: Ground Floor; Sill Height: 0 mm
Dimensions - Area: 2.27348 m2; Volume: 0.0756413 m3
Identity Data - Mark: 2
Other - Family: Doors_IntSgl: 810x2110mm; Family and Type: Doors_IntSgl: 810x2110mm; Head Height: 2110 mm; Host Id: Basic Wall: Wall-Partn_12P-70MStd-12P; Type: Doors_IntSgl: 810x2110mm; Type Id: Doors_IntSgl: 810x2110mm
Phasing - Phase Created: New Construction

# IfcFurniture: 1120x940x350mm (2)
In: 1 - Living room
Type - ElementType: 1120x940x350mm; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Metal - Chrome, Fabric - Blue, Glossy
Type - Identity Data - Assembly Code: E2020200; Assembly Description: Furniture & Accessories; Keynote: N; Type Name: 1120x940x350mm
Type - Materials and Finishes - Material Frame: Metal - Chrome; Material Seat: Fabric - Blue, Glossy
Type - Other - Category: Furniture; Family Name: Furniture_Chair_Viper
Constraints - Offset: 0 mm; Level: Level: Ground Floor; Moves With Nearby Elements: no; Host: Floor : Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC
Dimensions - Area: 3.7979 m2; Volume: 0.33903 m3
Other - Family: Furniture_Chair_Viper: 1120x940x350mm; Family and Type: Furniture_Chair_Viper: 1120x940x350mm; Type: Furniture_Chair_Viper: 1120x940x350mm; Type Id: Furniture_Chair_Viper: 1120x940x350mm
Phasing - Phase Created: New Construction
Name (Furniture_Chair_Viper:1120x940x350mm:...)
291916
292127

# IfcFurniture: 1200x550x450mm, Furniture_Table_Coffee_1:1200x550x450mm:293046
In: 1 - Living room
Type - ElementType: 1200x550x450mm; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Wood - Birch
Type - Dimensions - Height: 450 mm; Leg Width: 40 mm; Length: 1200 mm; Width: 550 mm
Type - Identity Data - Assembly Code: E2020200; Assembly Description: Furniture & Accessories; Cost: 0; Description: Coffee table; Keynote: N; Manufacturer: Revit; Type Name: 1200x550x450mm
Type - Materials and Finishes - Material: Wood - Birch
Type - Other - Category: Furniture; Family Name: Furniture_Table_Coffee_1
Pset_ManufacturerTypeInformation - Manufacturer: Revit
Constraints - Level: Level: Ground Floor; Offset: 0 mm; Moves With Nearby Elements: no; Host: Floor : Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC
Dimensions - Area: 0.869602 m2; Volume: 0.029939 m3
Other - Family: Furniture_Table_Coffee_1: 1200x550x450mm; Family and Type: Furniture_Table_Coffee_1: 1200x550x450mm; Type: Furniture_Table_Coffee_1: 1200x550x450mm; Type Id: Furniture_Table_Coffee_1: 1200x550x450mm
Phasing - Phase Created: New Construction

# IfcFurniture: 1370x600x1170mm, Furniture_Piano:1370x600x1170mm:293961
In: 1 - Living room
Type - ElementType: 1370x600x1170mm; Material: Wood - Mahogany
Type - Dimensions - Depth: 600 mm; Height: 1170 mm; Width: 1370 mm
Type - Identity Data - Keynote: N; Type Name: 1370x600x1170mm
Type - Other - Category: Furniture; Family Name: Furniture_Piano
Constraints - Level: Level: Ground Floor; Offset: 0 mm; Moves With Nearby Elements: no; Host: Floor : Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC
Dimensions - Area: 3.16717 m2; Volume: 0.502318 m3
Other - Family: Furniture_Piano: 1370x600x1170mm; Family and Type: Furniture_Piano: 1370x600x1170mm; Type: Furniture_Piano: 1370x600x1170mm; Type Id: Furniture_Piano: 1370x600x1170mm
Phasing - Phase Created: New Construction

# IfcFurniture: 1525x2007x355mm-Queen, Furniture_Bed_1:1525x2007x355mm-Queen:295878
In: 2 - Bedroom
Type - ElementType: 1525x2007x355mm-Queen; Material: Textile - White, Wood - Birch
Type - Dimensions - Length: 2007 mm; Width: 1800 mm
Type - Identity Data - Keynote: N; Type Name: 1525x2007x355mm-Queen
Type - Materials and Finishes - Material Frame: Wood - Birch; Material Mattress: Textile - White
Type - Other - Category: Furniture; Family Name: Furniture_Bed_1
Constraints - Level: Level: Ground Floor; Moves With Nearby Elements: no; Host: Floor : Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC
Dimensions - Area: 7.24286 m2; Volume: 0.792312 m3
Other - Family: Furniture_Bed_1: 1525x2007x355mm-Queen; Family and Type: Furniture_Bed_1: 1525x2007x355mm-Queen; Type: Furniture_Bed_1: 1525x2007x355mm-Queen; Type Id: Furniture_Bed_1: 1525x2007x355mm-Queen
Phasing - Phase Created: New Construction

# IfcFurniture: 1525x762mm, Furniture_Desk:1525x762mm:287689
In: 2 - Bedroom
Type - ElementType: 1525x762mm; Material: Laminate, Ivory, Matte, Steel, Chrome Plated, Cherry
Type - Identity Data - Keynote: N; Type Name: 1525x762mm
Type - Other - Category: Furniture; Body Material: Laminate, Ivory, Matte; Depth: 762 mm; Family Name: Furniture_Desk; Handle/Leg Material: Steel, Chrome Plated; Height: 762 mm; Leg Height: 152 mm; Top Material: Cherry; Width: 1525 mm
Constraints - Level: Level: Ground Floor; Host: Floor : Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC; Moves With Nearby Elements: no
Dimensions - Area: 4.27423 m2; Volume: 0.432091 m3
Other - Family: Furniture_Desk: 1525x762mm; Family and Type: Furniture_Desk: 1525x762mm; Type: Furniture_Desk: 1525x762mm; Type Id: Furniture_Desk: 1525x762mm
Phasing - Phase Created: New Construction

# IfcFurniture: 2000x1000x750mm_w-6_Seats, Furniture_Table_Dining_w-Chairs_Rectangular:2000x1000x750mm_w-6_Seats:289768
In: 1 - Living room
Type - ElementType: 2000x1000x750mm_w-6_Seats; Material: Wood - Birch
Type - Constraints - Centre Piece: 500 mm; Chair Side Spacing: 700 mm
Type - Dimensions - Leg Spacing Length: 1400 mm; Leg Spacing Width: 800 mm; Leg Width: 75 mm; Length: 2000 mm; Table Height: 750 mm; Table Top Thickness: 40 mm; Width: 1000 mm
Type - Graphics - Vis - End Chairs: yes
Type - Identity Data - Keynote: N; Type Name: 2000x1000x750mm_w-6_Seats
Type - Materials and Finishes - Material Chair Covering: Fabric - Beige; Material Chair Structure: Wood - Birch; Material Table: Wood - Birch
Type - Other - Category: Furniture; Family Name: Furniture_Table_Dining_w-Chairs_Rectangular
Constraints - Level: Level: Ground Floor; Offset: 0 mm; Moves With Nearby Elements: no; Host: Floor : Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC
Dimensions - Area: 3.36817 m2; Volume: 0.110515 m3
Other - Family: Furniture_Table_Dining_w-Chairs_Rectangular: 2000x1000x750mm_w-6_Seats; Family and Type: Furniture_Table_Dining_w-Chairs_Rectangular: 2000x1000x750mm_w-6_Seats; Type: Furniture_Table_Dining_w-Chairs_Rectangular: 2000x1000x750mm_w-6_Seats; Type Id: Furniture_Table_Dining_w-Chairs_Rectangular: 2000x1000x750mm_w-6_Seats
Phasing - Phase Created: New Construction

# IfcFurniture: 2290x950x340mm, Furniture_Couch_Viper:2290x950x340mm:290852
In: 1 - Living room
Type - ElementType: 2290x950x340mm; Classification: E2020200 Furniture & Accessories (Uniformat); Material: Metal - Chrome, Fabric - Blue, Glossy
Type - Identity Data - Assembly Code: E2020200; Assembly Description: Furniture & Accessories; Keynote: N; Type Name: 2290x950x340mm
Type - Materials and Finishes - Material Frame: Metal - Chrome; Material Seat: Fabric - Blue, Glossy
Type - Other - Category: Furniture; Family Name: Furniture_Couch_Viper
Constraints - Offset: 0 mm; Level: Level: Ground Floor; Moves With Nearby Elements: no; Host: Floor : Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC
Dimensions - Area: 6.89284 m2; Volume: 0.629499 m3
Other - Family: Furniture_Couch_Viper: 2290x950x340mm; Family and Type: Furniture_Couch_Viper: 2290x950x340mm; Type: Furniture_Couch_Viper: 2290x950x340mm; Type Id: Furniture_Couch_Viper: 2290x950x340mm
Phasing - Phase Created: New Construction

# IfcFurniture: Chair - Dining (6)
In: 1 - Living room
Type - ElementType: Chair - Dining; Material: Wood - Birch, Fabric - Beige
Type - Identity Data - Keynote: N; Type Name: Chair - Dining
Type - Materials and Finishes - Material Chair Covering: Fabric - Beige; Material Structure: Wood - Birch
Type - Other - Category: Furniture; Family Name: Chair - Dining
Constraints - Level: Level: Ground Floor; Offset: 0 mm; Moves With Nearby Elements: no; Host: Level : Ground Floor
Dimensions - Area: 0.552176 m2; Volume: 0.0092401 m3
Other - Family: Chair - Dining: Chair - Dining; Family and Type: Chair - Dining: Chair - Dining; Type: Chair - Dining: Chair - Dining; Type Id: Chair - Dining: Chair - Dining
Phasing - Phase Created: New Construction
Name (Chair - Dining:Chair - Dining:...)
289769
289770
289771
289772
290097
290098

# IfcMember: Curtain Wall:Curtain_Wall-Exterior_Glazing:8490 (20)
In: Ground Floor
PredefinedType: MULLION; Material: Aluminium
Constraints - Level: Level: Ground Floor; Angle: 0 deg; Offset: 0 mm
Other - Host Id: Curtain Wall: Curtain_Wall-Exterior_Glazing; Category: Curtain Wall Mullions; Family: Rectangular Mullion: 30mm_Square; Family and Type: Rectangular Mullion: 30mm_Square; Type: Rectangular Mullion: 30mm_Square; Type Id: Rectangular Mullion: 30mm_Square; Family Name: Rectangular Mullion
Phasing - Phase Created: New Construction
Pset_MemberCommon - IsExternal: yes; LoadBearing: yes; Reference: 30mm_Square
Construction - Corner Mullion: no; Position: Perpendicular to Face; Thickness: 30 mm
Dimensions - Width on side 1: 15 mm; Width on side 2: 15 mm
Identity Data - Keynote: H11; Type Name: 30mm_Square
Materials and Finishes - Material: Aluminium
Name (Curtain Wall:Curtain_Wall-Exterior_Glazing:...) | Area (m2) | Length (mm) = Span (mm) | Volume (m3)
8490 | 0.118776 | 1977.63 | 0.00176689
8490 | 0.122763 | 2043.57 | 0.00182698
8490 | 0.114319 | 1895.24 | 0.00170129
2 x 8490 | 0.1113 | 1840 | 0.001656
8490 | 0.1122 | 1855 | 0.0016695
8490 | 0.165501 | 2751.31 | 0.00246783
8490 | 0.148889 | 2473.7 | 0.00221887
8490 | 0.193174 | 3235.07 | 0.00288397
8490 | 0.1981 | 3316.84 | 0.00295795
4 x 8490 | 0.0962 | 1588.33 | 0.0014295
2 x 8490 | 0.0971 | 1603.33 | 0.001443
4 x 8490 | 0.165979 | 2751.31 | 0.00247618

# IfcOpeningElement: Opening (7)
In: Ground Floor
PredefinedType: OPENING
Name | Depth (mm) | Height (mm) | Width (mm)
Windows_Sgl_Plain:1810x1210mm:287567:1 | 290 | 1810 | 1210
Windows_Sgl_Plain:1810x1210mm:286238:1 | 290 | 1810 | 1210
Windows_Sgl_Plain:1810x1210mm:286188:1 | 290 | 1810 | 1210
Doors_IntSgl:810x2110mm:285959:1 | 95 | 810 | 2110
Doors_IntSgl:810x2110mm:285996:1 | 95 | 810 | 2110
Doors_ExtDbl_Flush:1810x2110mm:285860:1 | 290 | 1810 | 2110
Windows_Sgl_Plain:1810x1210mm:286105:1 | 290 | 1810 | 1210

# IfcPlate: Glazed (6)
In: Ground Floor
Type - ElementType: Glazed; PredefinedType: CURTAIN_PANEL; Material: Glass
Type - Analytical Properties - Analytic Construction: 1/8 in Pilkington single glazing; Heat Transfer Coefficient (U): 6.7069; Solar Heat Gain Coefficient: 0.86; Thermal Resistance (R): 0.1491; Visual Light Transmittance: 0.9
Type - Constraints - Offset: 37 mm
Type - Dimensions - Thickness: 25 mm
Type - Identity Data - Keynote: H11; Type Name: Glazed
Type - Materials and Finishes - Material: Glass
Type - Other - Category: Curtain Panels; Family Name: System Panel
Constraints - Level: Level: Ground Floor
Other - Family: System Panel: Glazed; Family and Type: System Panel: Glazed; Host Id: Curtain Wall: Curtain_Wall-Exterior_Glazing; Type: System Panel: Glazed; Type Id: System Panel: Glazed
Phasing - Phase Created: New Construction
Pset_PlateCommon - IsExternal: yes; Reference: Glazed; LoadBearing: yes; ThermalTransmittance: 6.7069 kg/K/s3
Name (System Panel:Glazed:...) | Area (m2) | Volume (m3)
285583 | 5.50272 | 0.137568
285586 | 6.27272 | 0.156818
285588 | 5.83009 | 0.145751
285685 | 4.49381 | 0.112345 | Dimensions - Height: 2751.31 mm; Width: 1633.33 mm
285688 | 4.49381 | 0.112345 | Dimensions - Height: 2751.31 mm; Width: 1633.33 mm
285690 | 4.49381 | 0.112345 | Dimensions - Height: 2751.31 mm; Width: 1633.33 mm

# IfcRoof: Basic Roof:Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr:45441, Basic Roof:Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr:286419
In: Roof
Material: Concrete, Sand/Cement Screed
Pset_RoofCommon - IsExternal: yes; Reference: Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr; TotalArea: 117.43 m2; ProjectedArea: 108.118 m2; ThermalTransmittance: 7.80566 kg/K/s3
Constraints - Related to Mass: no; Room Bounding: yes; Extrusion End: -14145 mm; Extrusion Start: 695.982 mm; Level Offset: 0 mm; Reference Level: Level: Roof; Work Plane: Basic Wall : Wall-Ext_102Bwk-75Ins-100LBlk-12P
Construction - Fascia Depth: 0 mm; Rafter Cut: Plumb Cut; Default Thickness: 116.5 mm
Dimensions - Area: 117.43 m2; Thickness: 116.5 mm; Volume: 13.6535 m3
Other - Category: Roofs; Family: Basic Roof: Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr; Family and Type: Basic Roof: Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr; Type: Basic Roof: Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr; Type Id: Basic Roof: Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr; Family Name: Basic Roof
Phasing - Phase Created: New Construction
Analytical Properties - Roughness: 3; Absorptance: 0.7; Heat Transfer Coefficient (U): 7.80566; Thermal mass: 171350; Thermal Resistance (R): 0.128112
Graphics - Coarse Scale Fill Color: 0
Identity Data - Type Name: Roof_Flat-4Felt-150Ins-50Scr-150Conc-12Plr

# IfcSlab: Floor:Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC, Floor:Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC:286349
In: Ground Floor
PredefinedType: FLOOR; Material: Concrete, Sand/Cement Screed 65 mm, Vapor Retarder 0 mm, Rigid insulation 80 mm, Air 150 mm, Damp-proofing 0 mm, Concrete Masonry, Floor Block 100 mm, Concrete, Precast 75 mm
Pset_SlabCommon - IsExternal: no; LoadBearing: yes; Reference: Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC; ThermalTransmittance: 0.117438 kg/K/s3; PitchAngle: 0 deg
BaseQuantities - GrossArea: 146.199 m2; GrossVolume: 68713.6 m3; Perimeter: 51070 mm; Width: 470 mm
Constraints - Related to Mass: no; Room Bounding: yes; Level: Level: Ground Floor; Height Offset From Level: 0 mm
Dimensions - Area: 146.199 m2; Perimeter: 51070 mm; Thickness: 470 mm; Volume: 68.7136 m3
Other - Category: Floors; Family: Floor: Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC; Family and Type: Floor: Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC; Type: Floor: Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC; Type Id: Floor: Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC; Family Name: Floor
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analytical Properties - Roughness: 3; Absorptance: 0.7; Heat Transfer Coefficient (U): 0.117438; Thermal mass: 365549; Thermal Resistance (R): 8.51516
Construction - Function: Interior; Default Thickness: 470 mm
Graphics - Coarse Scale Fill Pattern: Solid fill; Coarse Scale Fill Color: 0
Identity Data - Keynote: E60/130; Type Name: Floor-Grnd-Susp_65Scr-80Ins-100Blk-75PC
Materials and Finishes - Structural Material: Concrete Masonry, Floor Block

# IfcSlab: Floor:Simple floor, Floor:Simple floor:295048
In: Roof
PredefinedType: FLOOR; Material: Concrete, Sand/Cement Screed 65 mm, Concrete Masonry, Floor Block 100 mm
Pset_SlabCommon - IsExternal: no; LoadBearing: yes; PitchAngle: 0 deg; Reference: Simple floor; ThermalTransmittance: 6.33939 kg/K/s3
BaseQuantities - GrossArea: 80.2629 m2; GrossVolume: 13243.4 m3; Perimeter: 39470 mm; Width: 165 mm
Constraints - Related to Mass: no; Room Bounding: yes; Height Offset From Level: 0 mm; Level: Level: Roof
Dimensions - Area: 80.2629 m2; Perimeter: 39470 mm; Thickness: 165 mm; Volume: 13.2434 m3
Other - Category: Floors; Family: Floor: Simple floor; Family and Type: Floor: Simple floor; Type: Floor: Simple floor; Type Id: Floor: Simple floor; Family Name: Floor
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no
Analytical Properties - Roughness: 3; Absorptance: 0.7; Heat Transfer Coefficient (U): 6.33939; Thermal mass: 249332; Thermal Resistance (R): 0.157744
Construction - Function: Interior; Default Thickness: 165 mm
Graphics - Coarse Scale Fill Pattern: Solid fill; Coarse Scale Fill Color: 0
Identity Data - Keynote: E60/130; Type Name: Simple floor
Materials and Finishes - Structural Material: Concrete Masonry, Floor Block

# IfcWall: Basic Wall:Wall-Ext_102Bwk-75Ins-100LBlk-12P (3)
In: Ground Floor
Type - Analytical Properties - Absorptance: 0.7; Heat Transfer Coefficient (U): 0.235926; Roughness: 3; Thermal mass: 300303; Thermal Resistance (R): 4.23862
Type - Construction - Function: Exterior; Width: 290 mm; Wrapping at Inserts: Both
Type - Graphics - Coarse Scale Fill Color: 12632256; Coarse Scale Fill Pattern: Solid fill
Type - Identity Data - Keynote: 31120; Type Name: Wall-Ext_102Bwk-75Ins-100LBlk-12P
Type - Materials and Finishes - Structural Material: Concrete Masonry Units _Low Density
Type - Other - Category: Walls; Family Name: Basic Wall
Material: Brick, Common, Fiberglass Batt, Concrete Masonry Units _Low Density, Plaster
Constraints - Base Offset: 0 mm; Base Constraint: Level: Ground Floor; Base Extension Distance: 0 mm; Base is Attached: no; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: yes; Top Offset: 0 mm; Unconnected Height: 8000 mm
Other - Family: Basic Wall: Wall-Ext_102Bwk-75Ins-100LBlk-12P; Family and Type: Basic Wall: Wall-Ext_102Bwk-75Ins-100LBlk-12P; Type: Basic Wall: Wall-Ext_102Bwk-75Ins-100LBlk-12P; Type Id: Basic Wall: Wall-Ext_102Bwk-75Ins-100LBlk-12P
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_WallCommon - Reference: Wall-Ext_102Bwk-75Ins-100LBlk-12P; LoadBearing: no; ExtendToStructure: yes; IsExternal: yes; ThermalTransmittance: 0.235926 kg/K/s3
Name (Basic Wall:Wall-Ext_102Bwk-75Ins-100LBlk-12P:...) | Area (m2) | Length (mm) | Volume (m3)
285330 | 26.4829 | 14000 | 7.69015
285395 | 17.9995 | 5800 | 5.11547
285459 | 17.9585 | 9100 | 5.23393

# IfcWallStandardCase: Basic Wall:Wall-Partn_12P-70MStd-12P (2)
In: Ground Floor
Type - Material: Plaster 12.5 mm, Metal Stud Layer 70 mm, Plaster 12.5 mm
Type - Analytical Properties - Roughness: 3; Absorptance: 0.7; Heat Transfer Coefficient (U): 0.350998; Thermal mass: 26964.3; Thermal Resistance (R): 2.84902
Type - Construction - Wrapping at Inserts: Both; Function: Interior; Width: 95 mm
Type - Graphics - Coarse Scale Fill Pattern: Solid fill; Coarse Scale Fill Color: 12632256
Type - Identity Data - Type Name: Wall-Partn_12P-70MStd-12P
Type - Materials and Finishes - Structural Material: Metal Stud Layer
Type - Other - Category: Walls; Family Name: Basic Wall
BaseQuantities - Height: 2335 mm; Width: 95 mm
Constraints - Base Offset: 0 mm; Base Constraint: Level: Ground Floor; Base Extension Distance: 0 mm; Base is Attached: no; Location Line: Wall Centerline; Related to Mass: no; Room Bounding: yes; Top Extension Distance: 0 mm; Top is Attached: yes; Top Offset: 0 mm; Top Constraint: Level: Roof; Unconnected Height: 2500 mm
Other - Family: Basic Wall: Wall-Partn_12P-70MStd-12P; Family and Type: Basic Wall: Wall-Partn_12P-70MStd-12P; Type: Basic Wall: Wall-Partn_12P-70MStd-12P; Type Id: Basic Wall: Wall-Partn_12P-70MStd-12P
Phasing - Phase Created: New Construction
Structural - Enable Analytical Model: no; Structural: no; Structural Usage: Non-bearing
Pset_WallCommon - IsExternal: no; LoadBearing: no; ExtendToStructure: yes; Reference: Wall-Partn_12P-70MStd-12P; ThermalTransmittance: 0.350998 kg/K/s3
Name (Basic Wall:Wall-Partn_12P-70MStd-12P:...) | BaseQuantities, Length (mm) | GrossFootprintArea (m2) | GrossSideArea (m2) = Area (m2) | GrossVolume (m3) = Volume (m3) | Dimensions, Length (mm)
285792 | 5510 | 0.52345 | 9.44765 | 0.897527 | 5800
285846 | 4452.5 | 0.422988 | 10.3966 | 0.987676 | 4645

# IfcWindow: 1810x1210mm (4)
In: Ground Floor
Type - PredefinedType: WINDOW; ParameterTakesPrecedence: no; Material: Window Frame, Glass
Type - Analytical Properties - Analytic Construction: Large single-glazed windows; Heat Transfer Coefficient (U): 5.5617; Solar Heat Gain Coefficient: 0.86; Thermal Resistance (R): 0.179801; Visual Light Transmittance: 0.9
Type - Construction - Wall Closure: By host; Wrap Layers (Ext) from Ext: 102.5 mm; Wrap Layers (Int) from Ext: 177.5 mm
Type - Dimensions - Cavity Closer Depth: 85 mm; Cavity Closer Offset from Ext: 102.5 mm; Cavity Closer Width: 50 mm; Cill Depth: 87.5 mm; Frame Depth: 65 mm; FrameOffset - External: 50 mm; Glazing Thickness: 24 mm; Height: 1210 mm; Rough Height: 1210 mm; Rough Width: 1810 mm; Width: 1810 mm; Window Board Extension: 25 mm; Window Board Projection: 25 mm
Type - Graphics - Vis - Cavity Closers: yes
Type - Identity Data - Keynote: L10; Manufacturer: Revit; Type Mark: 49; Type Name: 1810x1210mm
Type - Materials and Finishes - Material Frame: Window Frame; Material Glass: Glass; Material Trim: Window Frame
Type - Other - Category: Windows; Default Head Height: 2110 mm; Family Name: Windows_Sgl_Plain
OverallHeight: 1210 mm; OverallWidth: 1810 mm
Pset_WindowCommon - IsExternal: yes; Reference: 1810x1210mm; ThermalTransmittance: 5.5617 kg/K/s3
Pset_ManufacturerTypeInformation - Manufacturer: Revit
BaseQuantities - Height: 1210 mm; Width: 1810 mm; Area: 3.53486 m2
Constraints - Level: Level: Ground Floor; Sill Height: 900 mm
Dimensions - Area: 3.53486 m2; Volume: 0.0884819 m3
Other - Host Id: Basic Wall: Wall-Ext_102Bwk-75Ins-100LBlk-12P; Family: Windows_Sgl_Plain: 1810x1210mm; Family and Type: Windows_Sgl_Plain: 1810x1210mm; Head Height: 2110 mm; Type: Windows_Sgl_Plain: 1810x1210mm; Type Id: Windows_Sgl_Plain: 1810x1210mm
Phasing - Phase Created: New Construction
Name (Windows_Sgl_Plain:1810x1210mm:...) | Mark
286105 | 1
286188 | 2
286238 | 3
287567 | 4
