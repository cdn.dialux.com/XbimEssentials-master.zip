Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [Специальная], Option [Drawing Scale: 1.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Visible elements (on all stories)], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: On], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Container Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Property Type Element Parameter: On], Option [Quantity Type Element Parameter: On], Option [IFC Base Quantities: Off], Option [Window Door Lining and Panel Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: On]
File name: D:\IFC\Building1.ifc
Time: 2018-08-14T18:11:58
Author: Architect
Organization: Building Designer Office
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 21.0.0 RUS FULL Windows version (IFC add-on version: 5021 RUS FULL).
Authorization: The authorising person

# IfcSite, Местность
RefLatitude: 55, 45, 0, 0; RefLongitude: 37, 35, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, 1-й этаж
In: Здание
Elevation: 0 mm

# IfcDoor: Однопольная Дверь 21, ДВ-001
In: 1-й этаж
Type - OperationType: SINGLE_SWING_LEFT; ParameterTakesPrecedence: no; Sizeable: no
Type - Свойства Отделки Двери - LiningDepth: 115 mm; LiningThickness: 40 mm; LiningOffset: 115 mm; CasingThickness: 50 mm; CasingDepth: 19 mm
Type - Свойства Панели Двери - Панель 1 - PanelDepth: 40 mm; PanelOperation: SWINGING; PanelWidth: 1; PanelPosition: MIDDLE
OverallHeight: 2100 mm; OverallWidth: 900 mm; Classification: Дверь (Классификация ARCHICAD); Material: Фон (7), Воздушное Пространство (6), Передний План, Изоляция 01, Изоляция 02
Pset_DoorCommon - SecurityRating: Не определено; ThermalTransmittance: 0; GlazingAreaFraction: 1.14117; HandicapAccessible: no; FireExit: no; SelfClosing: no; SmokeStop: no; IsExternal: no
Pset_DoorWindowGlazingType - IsTempered: no; IsLaminated: no; IsCoated: no; IsWired: no
Pset_FireRatingProperties - IsCombustible: no
Pset_ManufacturerOccurrence - BarCode: Не определено
Pset_ManufacturerTypeInformation - ModelLabel: Не определено
ArchiCADProperties - ID Элемента: ДВ-001; Связь и ID Элемента: ДВ-001; Cлой: Конструктив - Стены Несущие; Имя Библиотечного Элемента: Однопольная Дверь 21; Строительный Материал / Многослойная / Профиль / Штриховка: Фон; Заблокирован: no; Собственный Этаж: 1-й этаж; Тип: Дверь; Родительский ID: СТН-003; Покрытия (Все): Дерево - Сосна Продольная Горизонтальная; Стекло - Прозрачное Быстрое; Расположение: Внутри; Статус Реконструкции: Существующий; Конструктивная Функция: Ненесущий Элемент; Показ в Фильтре Реконструкции: Все Релевантные Фильтры; Размеры Четверти: 900×2 100; Размеры Отверстия в Стене: 900×2 100; Размеры Блока: 900×2 100; Размеры Выхода: 820×2 060; Размеры Полотна: 844×2 072; Номинальные Размеры Ш x В: 900×2 100; Номинальные Размеры Ш x В x Т: 900×2 100×300; Конструкция Стены: Общая Конструкция Стены/Оболочки; Ориентация: П; Имя Библиотечного Элемента Проема: Однопольная Дверь 21; Индекс Штриховки Стороны Открывания: Фон; Классификация ARCHICAD - 21: Дверь
AC_Pset_Однопольная_Дверь_21 - Контуры Стены (0-нет, 1-все, 2-сбоку, 3-длина): 0; Узловые Точки 0-Нет,1-2D, 2-3D, 3-Все: 3; Показ Узловых 2D Точек в 3D: yes; Показ на Плане Этажа: 3; Угол Расположения Отверстия: 0 deg; Покрытия Отверстия по Параметрам Стены: yes; Стык Покрытий в Проеме Искривлен в Криволинейных Стенах: no; Тип Стены: 1; Тип Направления Стены: 1; Расположение Привязки Четверти: 1; Направление Открывания: 0; Зеркально: no; Значение Подоконной Ниши: 3; Демонтаж / Новая Конструкция: 1; Тип Штриховки Новой Стены: Металл / Твердый Сплав; Перо Штриховки Новой Стены: Общее - Чертеж; Перо Фона Штриховки Новой Стены: Фон - Цвет 1; Показ новой конструкции Стены: no; Тип Линии Демонтажа: 1; Показ Параметра Демонтажа/Нового Элемента: no; Показать как Фрамугу: no; Боковая Панель (gs_SidelightTransomRelation): Под Фрамугой; Боковая Панель (gs_SidelightTransomRelation_m): 1; Боковая Панель 1: no; Боковая Панель 2: no; Фрамуга: no; Одинаковый Допуск: yes; Номинальный Размер: 0; Использовать Размеры Проема как Номинальные: yes; Использовать Размеры Четверти как Номинальные: no; Использовать Размеры Блока как Номинальные: no; Использовать Размеры Прохода как Номинальные: no; Использовать Размеры Полотна как Номинальные: no; Применить Номинальные Размеры для Выбранного: no; Показ Редактируемых Узловых Точек: yes; 2D-детализация: 1; Показ Четвертей в Символе: 1; Символический Показ Проема: no; 3D-детализация: 2; Направление Открывания Боковой Панели (gs_opening_dir_sl): Противоположно Двери; Направление Открывания Боковой Панели (gs_opening_dir_sl_m): 2; Коробка Двери (gs_pocket_door_frame): yes; Стиль Коробки (gs_frame_style): Простой Уступ; Стиль Коробки (gs_frame_style_m): 3; Толщина Коробки = Толщине Стены: no; Единая Толщина Коробки: yes; Полотно по Центру: yes; Единая Ширина Коробки: yes; Стиль Коробки Изменен Автоматически: no; Количество Дверных Полотен: 4; Количество Дверных Полотен - Сторона 2: 3; Стиль Полотна Двери: 46; Конфигурация Полотен (gs_LeavesConfig): Одинаковые Полотна; Конфигурация Полотен (gs_iLeavesConfig): 1; Расположение Раскладки (gs_grill_pos): Посередине; Расположение Раскладки (gs_grill_pos_m): 3; Количество Стекол по Вертикали: 4; Количество Стекол по Горизонтали: 3; Стекол по Вертикали в Боковой Створке 1: 4; Стекол по Горизонтали со Стороны 1: 3; Показать в Символе как Остекление: no; Показать Китайский Символ Двери: no; Показать Символ Герметичной Панели: no; Ручка (gs_handle_type): Нет; Ручка (gs_handle_type_m): 0; Показ Ручки в Символе: no; Защитная Пластина Снаружи (bKickBoardOut): no; Защитная Пластина Внутри (bKickBoardIn): no; Одинаковые Створки: no; Тип Открывания (gs_optype_m_05): 3; Тип Открывания (gs_optype_m_09): 3; Тип Открывания (gs_optype_m_02): 1; Тип Открывания (gs_optype_m_06): 1; Тип Открывания (gs_optype_m_10): 1; Створка (MullionStyle_00): Без Раскладки; Створка (iMullionStyle_00): 1; Створка (iMullionStyle_05): 1; Створка (iMullionStyle_09): 1; Створка (iMullionStyle_02): 1; Створка (iMullionStyle_06): 1; Створка (iMullionStyle_10): 1; Редактируемые Узловые Точки Сетки: yes; Расположение Раскладки (MullionPosition): Посередине; Расположение Раскладки (iMullionPosition): 3; Стекол по Вертикали в Основной Боковой Створке 1: 4; Стекол по Горизонтали в Основной Боковой Створке 1: 2; Стекол по Вертикали 2 в Основной Боковой Створке 1: 4; Стекол по Горизонтали 2 в Основной Боковой Створке 1: 2; Стекол по Вертикали в Основной Боковой Створке 2: 4; Стекол по Горизонтали в Основной Боковой Створке 2: 2; Стекол по Вертикали 2 в Основной Боковой Створке 2: 4; Стекол по Горизонтали 2 в Основной Боковой Створке 2: 2; Стекол по Вертикали в Средней Фрамуге: 2; Стекол по Горизонтали в Средней Фрамуге: 2; Стекол по Вертикали 2 в Средней Фрамуге: 2; Стекол по Горизонтали 2 в Средней Фрамуге: 2; Стекол по Вертикали в Боковой Фрамуге 1: 2; Стекол по Горизонтали в Боковой Фрамуге 1: 2; Стекол по Вертикали 2 в Боковой Фрамуге 1: 2; Стекол по Горизонтали 2 в Боковой Фрамуге 1: 2; Стекол по Вертикали в Боковой Фрамуге 2: 2; Стекол по Горизонтали в Боковой Фрамуге 2: 2; Стекол по Вертикали 2 в Боковой Фрамуге2: 2; Стекол по Горизонтали 2 в Боковой Фрамуге 2: 2; Наружный Наличник (gs_trim_outside): yes; Тип Наружного Наличника (gs_trimtype_out): Простой; Тип Наружного Наличника (gs_trimtype_out_int): 1; Тип Верхнего Наружного Наличника: 1; Консольные Выступы: yes; Тип Консольного Выступа: 1; Покрытие Наружной Поверхности Стены: yes; Одинаковая Ширина Наличников (gs_trim_outside_uniform): yes; Внутренний Наличник (gs_trim_inside): yes; Тип Внутреннего Наличника (gs_trimtype_in): Простой; Тип Внутреннего Наличника (gs_trimtype_in_int): 1; Покрытие Внутренней Поверхности Стены: yes; Одинаковая Ширина Наличников (gs_trim_inside_uniform): yes; Порог (bThreshold): no; Тип Порога: 2; Угол Порога: 3.1996 deg; Порог Изменен Автоматически: no; Отлив - Дверь: no; Отлив - Боковая Панель 1: no; Отлив - Боковая Панель 2: no; Подставочный Профиль: no; Тип Отлива: 1; Наклон Отлива: 3 deg; Искривление Отлива в Криволинейных Стенах: yes; Изоляция под Отливом: yes; Использовать Слой Изоляции Стены: no; Детализация Кирпичного Отлива: 1; Стиль Отлива Изменен Автоматически: no; Подоконная Доска Боковой Панели 1: no; Подоконная Доска Боковой Панели 2: no; Дверная Доска: no; Угол Доски: 0 deg; Искривление Подоконника в Криволинейных Стенах: yes; Подоконная Доска в Многоугольной Стене: 1; Приточная Вентиляция: no; Тип Клапана Приточной Вентиляции: 2; Ставни: no; Тип Ставней (gs_sunShade_iType): 1; Активированные Типы Ставней: 126; Количество Панелей: 2; Количество Панелей 2: 1; Расположение Ставней (gs_shutter_panelPos): Симметрично; Расположение Ставней (gs_shutter_iPanelPos): 1; Автоматическая Высота Ставней: yes; Дополнительная Рама: no; Тип Отлива Направляющей (gs_slidingShutter_cover): Z-профиль; Тип Отлива Направляющей (gs_slidingShutter_iCover): 1; Складывание (gs_foldingShutter_stacking): Внутри; Складывание (gs_foldingShutter_iStacking): 1; Открыты в 3D: yes; Угол Открывания в 3D (gs_shutter_opAngle): 180 deg; Показ 2D-символа: yes; Показ Линий Открывания в Символе: no; Тип Ставней (gs_shutPanel_type): Стиль 1; Тип Ставней (gs_shutPanel_iType): 1; Различная Ширина Нижних Панелей: no; Автоматическая Ширина Ставней: yes; Поворот Ламелей: 30 deg; Отверстий по Горизонтали: 5; Отверстий по Вертикали: 8; Размещение Подъемного Рольставня (gs_shutRoll_placement): На Фасаде; Размещение Подъемного Рольставня (gs_shutRoll_iPlacement): 1; Тип Ставня (gs_shutRoll_boxType): Прямоугольник; Тип Ставня (gs_shutRoll_iBoxType): 1; Расположение (gs_shutRoll_railPos): На Наличнике; Расположение (gs_shutRoll_iRailPos): 1; Показ Наличника за Ставнями (gs_shutRoll_showCasingBehind): no; Изоляция за Ставнем (gs_shutRoll_cutWallBehind): no; Включить Высоту в Высоту Проема: no; Верхний Угол Ставня: 10 deg; Ширина Ставня по Умолчанию (gs_shutRoll_boxDefaultSize): Ширина Четверти; Ширина Ставня по Умолчанию (gs_shutRoll_iBoxDefaultSize): 1; Расположение Ламелей (gs_shutLam_placement): Фиксация на Фасаде; Расположение Ламелей (gs_shutLam_iPlacement): 1; Изоляция за Ставнем (gs_shutLam_cutWallBehind): no; Открытый Ставень: yes; Направляющая (gs_shutLam_bRail): yes; Расположение (gs_shutLam_railPos): На Наличнике; Расположение (gs_shutLam_iRailPos): 1; Показ Наличника за Ставнями (gs_shutLam_showCasingBehind): no; Угол Поворота Ламелей (gs_shutLam_rotation): 45 deg; Угол Поворота Ламелей (gs_shutLam2_rotation): 45 deg; Декоративная Перемычка (bMasonryArch): no; Декоративная Перемычка (gs_masonry_arch_int): 2; Тип Декоративной Перемычки (gs_masonry_arch_structure): Штукатурная; Тип Декоративной Перемычки (gs_masonry_arch_structure_int): 1; Без Пространства над Проемом: yes; Ниша над Проемом: yes; Угол Пяты: 75 deg; Специальное Покрытие Ниши: no; Тип Четверти (gs_reveal_type_new): Без Четверти - Торец; Тип Четверти (gs_reveal_type_int): 1; Тип Нижней Четверти (gs_reveal_type_bottom): Без Четверти; Тип Нижней Четверти (gs_reveal_type_bottom_int): 2; Ширина Боковой Четверти: 1; Одинаковая Ширина Четвертей: yes; Тип Наружной Четверти: Без Четверти; Тип Четверти (gs_reveal_doubleOuterTypeInt): 0; Тип Внутренней Четверти: Без Четверти; Тип Четверти (gs_reveal_doubleInnerTypeInt): 0; Угол Откоса со Стороны 2: 20 deg; Угол Откоса (gs_reveal_right_angle): 20 deg; Угол Верхней Стороны: 20 deg; Угол Нижней Стороны: 20 deg; Угол Наружного Откоса со Стороны 2: 20 deg; Угол Откоса (gs_reveal_outerRight_angle): 20 deg; Наружный Угол Верхнего Откоса: 20 deg; Наружный Угол Нижнего Откоса: 20 deg; Направляющие под Полотнами: no; Направляющая (gs_door_rail_ext): Откл.; Направляющая (gs_door_rail_ext_m): 1; Использовать Отделку Стены: no; Автоповорот Внутренней Поверхности Штукатурки: yes; Поворот Внутренней Поверхности Штукатурки: 0; Автоповорот Наружной Поверхности Штукатурки: yes; Поворот Наружной Поверхности Штукатурки: 0; Нанесение Размеров в 2D: no; Показ в 3D: no; Способ Замыкания (gs_closure_type): Без Замыкания; Способ Замыкания (gs_closure_type_int): 1; Сторона Проема (gs_cavity_side): Обе; Сторона Проема (iCavityClosureSide): 1; Поворачивающих Слоев: 1; Начало Нумерации (gs_nTurnDir): Снаружи; Начало Нумерации (iCavityClosureTurnDir): 1; Термовкладыш со Стороны 1: yes; Термовкладыш со Стороны 2: yes; Верхний Термовкладыш: no; Нижний Термовкладыш: no; Создать Термовкладыш Слоя: 1; Боковой Термовкладыш (gs_cc_dutch_ClosureToSide): 1; Зазор Наружного Слоя: yes; Продлить Слой до Термовкладыша: no; Термовкладыш: yes; Показ Термовкладыша: yes; Перо Контура (gs_penJoint): Проемы - Остекление в 3D и Линии открывания; Тип Линии Контура (gs_ltJoint): 1; Тип Штриховки (gs_fillJoint): Изоляция 01; Перо Штриховки (gs_penJointFg): Общее - Чертеж; Перо Фона Штриховки (gs_penJointBg): 2D-элементы - Штриховка Сечений; Специальное Покрытие: no; Покрытие: Дерево - Сосна Продольная Горизонтальная; Перо Контура (gs_penPlug): Проемы - Остекление в 3D и Линии открывания; Тип Линии Контура (gs_ltPlug): 1; Тип Штриховки (gs_fillPlug): Изоляция 01; Перо Штриховки (gs_penPlugFg): Общее - Чертеж; Перо Фона Штриховки (gs_penPlugBg): 2D-элементы - Штриховка Сечений; Измененная Боковая Четверть: 1; Редактируемая Сторона Стены: 1; Номер Редактируемого Слоя: 1; Поворот Слоя Внутрь: no; Считать Слой Штукатуркой: no; Толщина Поворота Внутрь: 1; Ориентация Штриховки: 1; Разделитель при Повороте Внутрь: no; Перо Разделительной Линии: Общее - Чертеж; Последняя Выбранная Сторона: no; Способ Замыкания Изменен Автоматически: no; Соединение Сбоку 1: no; Соединение Сбоку 2: no; Соединение Вверху: no; Тип Открывания (gs_leaf_optype): Распашная; Тип Открывания (gs_leaf_optype_m): 1; Открывание Конечной Панели 1: no; Открывание Конечной Панели 2: no; Угол Открывания в 2D: 90 deg; Угол открывания в 2D со Стороны 2: 90 deg; Угол Открывания в 3D (gs_open_3D): 0 deg; Угол Открывания Конечной Панели 2 в 3D: 0 deg; Угол Открывания Основной Боковой Створки 1 (openingAngle_05): 0 deg; Угол Открывания Основной Боковой Створки 1 (openingAngle2_05): 0 deg; Угол Открывания Основной Боковой Створки 2 (openingAngle_09): 0 deg; Угол Открывания Основной Боковой Створки 2 (openingAngle2_09): 0 deg; Угол Открывания Средней Фрамуги (openingAngle_02): 0 deg; Угол Открывания Средней Фрамуги (openingAngle2_02): 0 deg; Угол Открывания Фрамуги со Стороны 1 (openingAngle_06): 0 deg; Угол Открывания Фрамуги со Стороны 1 (openingAngle2_06): 0 deg; Угол Открывания Фрамуги со Стороны 2 (openingAngle_10): 0 deg; Угол Открывания Фрамуги со Стороны 2 (openingAngle2_10): 0 deg; Тип Линии Открывания в 2 стороны: 4; Замена ПМВ для 2D-символа: no; Тип Линии Открывания: 1; Форма Линии Открывания (or_SwingType): Криволинейная; Форма Линии Открывания (or_iSwingType): 1; Форма Линии Открывания (or_SlidingType): Нет; Форма Линии Открывания (or_iSlidingType): 0; Замена ПМВ для 3D-проекций: no; Показать Линию Открывания (or_bOplines3d): yes; Со Стороны Открывания (or_opLineType3dIn): Штриховая; Со Стороны Открывания (or_iOpLineType3dIn): 1; С Противоположной (or_opLineType3dOut): Сплошная Линия; С Противоположной (or_iOpLineType3dOut): 0; Ориентация Линии (or_oplineStyle): Ручка; Ориентация Линии (or_iOplineStyle): 1; Перо Линии Открывания в 2D/3D (or_opLinePen): Проемы - Общее; Перо Линии Открывания в 2D/3D (or_iOpLinePen): 3; Замена ПМВ для 3D-проекции Боковой Панели/Фрамуги: no; Показать Линию Открывания (or_bWinOplines3d): yes; Со Стороны Открывания (or_winOpLineType3dIn): Штриховая; Со Стороны Открывания (or_iWinOpLineType3dIn): 1; С Противоположной (or_winOpLineType3dOut): Сплошная Линия; С Противоположной (or_iWinOpLineType3dOut): 0; Ориентация Линии (or_winOplineStyle): Ручка; Ориентация Линии (or_iWinOplineStyle): 1; Перо Линии Открывания в 2D/3D (or_winOpLinePen): Проемы - Общее; Перо Линии Открывания в 2D/3D (or_iWinOpLinePen): 3; Перо Символа: Проемы - Общее; Перо Контура Коробки: Проемы - Линии в Сечении; Перо Сечения Наличника с Обеих Сторон: Проемы - Общее; Перо Контура Полотна: Проемы - Общее; Линия Контура Стены (gs_wcont_line): Откл.; Линия Контура Стены (iWallContourLine): 1; Тип Линии Внутреннего Контура Стены: 1; Тип Линии Наружного Контура Стены: 1; Тип Линии Невидимого Контура Стены Внутри: 4; Тип Линии Невидимого Контура Стены Снаружи: 4; Линия Контура Стены Боковой Панели (gs_wcont_line_sl): Обе Стороны; Линия Контура Стены Боковой Панели (iWallContourLineSl): 4; Тип Линии Внутреннего Контура Стены Боковой Панели: 1; Тип Линии Наружного Контура Стены Боковой Панели: 1; Тип Линии Невидимого Контура Стены Боковой Панели Внутри: 4; Тип Линии Невидимого Контура Стены Боковой Панели Снаружи: 4; Перо Контура Стены: Проемы - Общее; Использовать Штриховку: yes; Тип Штриховки Коробки: Фон; Перо Штриховки Коробки: Проемы - Штриховка Сечений; Перо Фона Штриховки Коробки: Фон - Цвет 1; Тип Штриховки Полотна: Воздушное Пространство; Перо Штриховки Полотна: Фон - Цвет 1; Перо Фона Штриховки Полотна: Фон - Цвет 1; Тип Штриховки Символа Герметизации: Передний План; Перо Штриховки Символа Герметизации: Общее - Чертеж; Перо Фона Штриховки Символа Герметизации: Общее - Чертеж; Тип Штриховки Символа Двери на Плане: Фон; Перо Штриховки Символа Двери на Плане: Фон - Цвет 1; Перо Фона Штриховки Символа Двери на Плане: Прозрачный; Тип Штриховки Символа Боковой Панели на Плане: Фон; Перо Штриховки Символа Боковой Панели на Плане: Фон - Цвет 1; Перо Фона Штриховки Символа Боковой Панели на Плане: Фон - Цвет 1; Тип Линии Порога и Отлива: 1; Перо Контура Сечения Порога: Проемы - Общее; Тип Штриховки Сечения Порога: Фон; Перо Штриховки Сечения Порога: Фон - Цвет 1; Перо Фона Штриховки Сечения Порога: Фон - Цвет 1; Перо Видимого Контура Отлива в 3D: Общее - Чертеж; Перо Контура Сечения Отлива: Общее - Чертеж; Тип Штриховки Сечения Отлива: Воздушное Пространство; Перо Штриховки Сечения Отлива (gs_sill_pen_fg): Фон - Цвет 1; Перо Штриховки Сечения Отлива (gs_sill_pen_bg): Фон - Цвет 1; Перо Контура Изоляции в Сечении: Общее - Чертеж; Тип Штриховки Изоляции в Сечении: Изоляция 01; Перо Штриховки Изоляции в Сечении: Общее - Чертеж; Перо Фона Штриховки Изоляции в Сечении: Фон - Цвет 1; Перо Видимого Контура Подоконника в 3D: Общее - Чертеж; Перо Контура Сечения Доски: Общее - Чертеж; Тип Штриховки Сечения Подоконника: Воздушное Пространство; Перо Штриховки Сечения Подоконника: Фон - Цвет 1; Перо Фона Штриховки Сечения Подоконника: Фон - Цвет 1; Тип Штриховки Внутреннего Наличника: Воздушное Пространство; Перо Штриховки Внутреннего Наличника: Фон - Цвет 1; Перо Фона Штриховки Внутреннего Наличника: Фон - Цвет 1; Тип Штриховки Наружного Наличника: Воздушное Пространство; Перо Штриховки Наружного Наличника: Фон - Цвет 1; Перо Фона Штриховки Наружного Наличника: Фон - Цвет 1; Тип Штриховки Сечения Перемычки: Фон; Перо Штриховки Сечения Перемычки: Фон - Цвет 1; Перо Фона Штриховки Сечения Перемычки: Фон - Цвет 1; Тип Штриховки Сечения Приточного Клапана: Воздушное Пространство; Перо Штриховки Сечения Приточного Клапана: Фон - Цвет 1; Перо Фона Штриховки Сечения Приточного Клапана: Фон - Цвет 1; Тип Линии Ставней в Символе: 1; Перо Линии Сечения Ставней: Общее - Чертеж; Перо Линии Видимого Контура в 3D/Сечении: Общее - Чертеж; Тип Штриховки Сечения Ставней: Фон; Перо Штриховки Сечения Ставней: Общее - Чертеж; Перо Фона Штриховки Сечения Ставней: Фон Окна; Тип Штриховки Изоляции Ставней: Изоляция 02; Перо Штриховки Изоляции Ставней: Общее - Чертеж; Перо Фона Штриховки Изоляции Ставней: Фон Окна; Тип Штриховки Видимых Поверхностей: Фон; Перо Штриховки Видимых Поверхностей: Фон - Цвет 1; Перо Фона Штриховки Видимых Поверхностей: Фон - Цвет 1; Значения Стороны Открывания (gs_opside_list): Специальный; Значения Стороны Открывания (gs_opside_list_m): 0; Соединения Коробки (gs_SashText_typ): Соединение Встык; Соединения Коробки (gs_SashText_typ_num): 2; Перо Коробки: Проемы - Общее; Перо Полотна: Проемы - Общее; Перо Остекления: Проемы - Остекление в 3D и Линии открывания; Перо Остекления Полотна: Проемы - Остекление в 3D и Линии открывания; Перо Декоративной Перемычки: Стены/Навесные Стены - Общее; Аппроксимация: 32; Отбрасывание Теней: yes; Одинаковые Покрытия Двери: no; Коробка Снаружи: Дерево - Сосна Продольная Горизонтальная; Коробка Внутри: Дерево - Сосна Продольная Горизонтальная; Полотно Снаружи: Дерево - Сосна Продольная Горизонтальная; Полотно Внутри: Дерево - Сосна Продольная Горизонтальная; Полотно 2: Дерево - Сосна Продольная Горизонтальная; Полотно 3: Дерево - Сосна Продольная Горизонтальная; Замок: Краска - Антрацит; Раскладка Снаружи (gs_grill_mat): Дерево - Сосна Продольная Горизонтальная; Раскладка Внутри (gs_grill_mat2): Дерево - Сосна Продольная Горизонтальная; Раскладка Снаружи (gs_leaf_grill_mat): Дерево - Сосна Продольная Горизонтальная; Раскладка Внутри (gs_leaf_grill_mat2): Дерево - Сосна Продольная Горизонтальная; Сплошная Панель Снаружи: Дерево - Сосна Продольная Горизонтальная; Сплошная Панель Внутри: Дерево - Сосна Продольная Горизонтальная; Стекло (gs_glass_mat): Стекло - Прозрачное Быстрое; Стекло (gs_leaf_glass_mat): Стекло - Прозрачное Быстрое; Направляющая (gs_rail_mat): Металл - Железо; Жалюзи Снаружи: Дерево - Сосна Продольная Горизонтальная; Жалюзи Внутри: Дерево - Сосна Продольная Горизонтальная; Защитная Пластина: Металл - Алюминий; Одинаковые Покрытия Наличников: yes; Внутренний Наличник (gs_trim_in_mat): Дерево - Сосна Продольная Горизонтальная; Наружный Наличник (gs_trim_out_mat): Дерево - Сосна Продольная Горизонтальная; Приточный Клапан: Металл - Алюминий; Панель Ставня: Дерево - Сосна Продольная Горизонтальная; Обвязка Ставня: Дерево - Сосна Продольная Горизонтальная; Корпус Рольставней: Металл - Сталь Нержавеющая; Планки Рольставней: Краска - Глянцевая Белая; Направляющая Ставней (gs_shutRoll_matRail): Краска - Глянцевая Белая; Корпус Наружных Жалюзи: Металл - Сталь Нержавеющая; Сегменты Наружных Жалюзи: Краска - Глянцевая Белая; Направляющая Ставней (gs_shutSliding_matRail): Металл - Сталь Нержавеющая; Порог (gs_treshold_mat): Дерево - Сосна Продольная Горизонтальная; Металлический Порог: Металл - Алюминий; Отлив (gs_sill_mat): Кирпич - Ложковая Кладка; Шов Кирпичного Отлива: Штукатурка - Шероховатая Белая; Подоконная Доска (gs_board_mat): Дерево - Сосна Продольная Горизонтальная; Ручка (gs_handle_mat): Металл - Сталь Нержавеющая; Аксессуары Ручек: Металл - Железо; Защитная Пластина Снаружи (matKickBoardOut): Металл - Сталь Нержавеющая; Защитная Пластина Внутри (matKickBoardIn): Металл - Сталь Нержавеющая; Кирпич Декоративной Перемычки: Кирпич - Ложковая Кладка; Раствор Декоративной Перемычки: Штукатурка - Шероховатая Белая; Замковый Камень Декоративной Перемычки: Камень - Песчаник 01; Ниша: Краска - Оксид Свинца Желтый; Дверь относится к Зоне, в которую она открывается: yes; Цена: 0; Расположение как: Специальный; Общая Площадь Остекления (gs_list_glassarea_tmp): 0; Коррекция Площади Остекления: no; Общая Площадь Остекления (gs_list_glassarea): 1.14117; Общий Периметр Остекления: 0; Приток Воздуха (мм2/л/м): 0; Тип Группы (FM_Type): Другой; Тип Группы (iFMType): 25; Вес Изделия: 0; Единица Веса: кг; Определение Ориентации Двери: 0; Ориентация Двери: П; Дверной Механизм: no; Тип Видеопанели: Нет Видеопанели; Устройство Доводчика: no; Ширина Полотен: 844; Операция IFC (ifc_optypestr): Дверь Однопольная Распашная; Операция IFC (ifc_optype): 1
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Высота: 2100 mm; Чистый Объем: 0.0781507 m3; Ширина: 900 mm; Отметка относительно Нуля Проекта: 0 mm; Отметка отн. 1-й уровень привязки: 150 mm; Отметка отн. 2-й уровень привязки: -3300 mm; Отметка отн. Уровня Моря: 0 mm; Отметка относительно Этажа: 0 mm; Смещение Основания: 0 mm; Площадь Поверхности: 9.18873 m2; Объем Проема О/Д: 0.567 m3; Номинальный Объем Проема О/Д: 0.567 m3; Площадь Поверхности Проема О/Д: 9.18873 m2; Номинальная Площадь Проема О/Д: 1.89 m2; Ширина Проема О/Д со Стороны Четверти: 900 mm; Высота Проема О/Д со Стороны Четверти: 2100 mm; Ширина Проема О/Д со Стороны, Противоположной Четверти: 900 mm; Высота Проема О/Д со Стороны, Противоположной Четверти: 2100 mm; Площадь Проема О/Д со Стороны Четверти: 1.89 m2; Площадь Проема О/Д со стороны, Противоположной Четверти: 1.89 m2; Номинальная Ширина Проема О/Д со Стороны Четверти: 900 mm; Номинальная Высота Проема О/Д со Стороны Четверти: 2100 mm; Номинальная Ширина Проема О/Д со Стороны, Противоположной Четверти: 900 mm; Номинальная Высота Проема О/Д стороны, Противоположной Четверти: 2100 mm; Номинальная Площадь Проема О/Д со Стороны Четверти: 1.89 m2; Номинальная Площадь Проема О/Д со стороны, Противоположной Четверти: 1.89 m2; Привязка По Низу/По Верху: 0 mm; Номинальная Высота Подоконника/Порога О/Д: 0 mm; Высота Подоконника/Порога О/Д со Стороны Четверти: 100 mm; Высота Подоконника/Порога О/Д со Стороны, Противоположной Четверти: 100 mm; Номинальная Высота Перемычки О/Д: 2100 mm; Высота Перемычки О/Д со Стороны Четверти: 2200 mm; Высота Перемычки О/Д со Стороны, Противоположной Четверти: 2200 mm; Толщина Стены: 300 mm; Толщина: 115 mm
AC_Equantity_Однопольная_Дверь_21 - Ширина: 900 mm; Высота: 2100 mm; Размер Z-профиля: 1000 mm; Отметка Низа: 1000 mm; Отметка Верха: 0 mm; Высота Отлива отн. Текущего Этажа: 0 mm; Четверть к Ядру Стены: 0 mm; Ширина Штриховки Новой Стены Справа: 150 mm; Ширина Штриховки Новой Стены Слева: 150 mm; Высота Пяты: 1840 mm; Ширина Боковой Панели 1 (gs_sidelight_width_right): 0 mm; Ширина Боковой Панели 1 (gs_sidelight_width_right_half): 150 mm; Ширина Боковой Панели 1 (gs_sidelight_width_right_orig): 300 mm; Высота Подоконника Боковой Панели 1: 0 mm; Ширина Боковой Панели 2 (gs_sidelight_width_left): 0 mm; Ширина Боковой Панели 2 (gs_sidelight_width_left_half): 300 mm; Ширина Боковой Панели 2 (gs_sidelight_width_left_orig): 600 mm; Высота Подоконника Боковой Панели 2: 0 mm; Высота Фрамуги: 300 mm; Смещение Оси Поворота: 275 mm; Боковой Допуск 1: 0 mm; Боковой Нижний Допуск 1: 0 mm; Нижний Допуск Боковой Панели 1: 0 mm; Боковой Допуск 2: 0 mm; Боковой Нижний Допуск 2: 0 mm; Нижний Допуск Боковой Панели 2: 0 mm; Верхний Допуск: 0 mm; Нижний Допуск: 0 mm; Ширина Проема в Стене: 900 mm; Высота Проема в Стене: 2100 mm; Ширина Четверти (ac_reveal_width): 900 mm; Высота Четверти: 2100 mm; Ширина Элемента: 900 mm; Высота Элемента: 2100 mm; Ширина Прохода: 820 mm; Высота Прохода: 2060 mm; Ширина Полотна: 844 mm; Высота Полотна: 2072 mm; Толщина Коробки: 115 mm; Толщина Коробки Внутри: 115 mm; Смещение Полотна: 0 mm; Ширина Коробки: 40 mm; Припуск Рамы: 10 mm; Толщина Наружной Коробки: 10 mm; Ширина Коробки Сбоку 1: 40 mm; Ширина Импоста Сбоку 1: 40 mm; Ширина Коробки Внизу Сбоку 1: 40 mm; Ширина Коробки Сбоку 2: 40 mm; Ширина Импоста Сбоку 2: 40 mm; Ширина Коробки Внизу Сбоку 2: 40 mm; Ширина Средника Фрамуги (gs_frame_width_transom): 40 mm; Ширина Коробки Вверху: 40 mm; Толщина Ограничителя Двери: 32 mm; Ширина Ограничителя Двери: 16 mm; Ширина Паза: 12 mm; Глубина Паза в 3D: 40 mm; Ширина Паза Боковой Панели и Фрамуги: 10 mm; Глубина Паза Боковой Панели и Фрамуги: 18 mm; Ширина Полотна со Стороны 1: 900 mm; Толщина Полотна: 40 mm; Ширина Боковой Обвязки Полотна: 100 mm; Ширина Правой Обвязки Полотна: 100 mm; Ширина Левой Обвязки Полотна: 100 mm; Ширина Обвязки Полотна Внизу: 200 mm; Ширина Обвязки Полотна Вверху: 100 mm; Ширина Средника Полотна: 25 mm; Подрезка Полотна: 0 mm; Ширина Раскладки (gs_grid_w): 12 mm; Толщина Раскладки (gs_grid_thk): 25 mm; Толщина Остекления: 12 mm; Высота Ручки: 1000 mm; Расположение Ручки: 50 mm; Высота Защитной Пластины: 100 mm; Высота Средника Боковой Панели 1: 900 mm; Высота Средника Боковой Панели со Стороны 2: 900 mm; Высота Средника Средней Фрамуги: 900 mm; Высота Средника Боковой Фрамуги 1: 900 mm; Высота Средника Боковой Фрамуги 2: 900 mm; Толщина Рамы Боковой Панели и Фрамуги: 44 mm; Ширина Средника Фрамуги (gs_sash_width): 67 mm; Ширина Рамы Боковой Панели: 67 mm; Ширина Раскладки (gw): 20 mm; Толщина Раскладки (gth): 25 mm; Ширина Раскладки Боковой Панели: 40 mm; Толщина Раскладки Боковой Панели: 115 mm; Ширина Консольного Выступа: 20 mm; Ширина со Стороны 1 (gs_tw_right_out): 50 mm; Ширина со Стороны 2 (gs_tw_left_out): 50 mm; Ширина Вверху (gs_tw_top_out): 50 mm; Толщина по Стене (gs_trim_thk_out): 19 mm; Толщина в Проеме (gs_trim_width_out): 25 mm; Смещение (gs_trim_offs_out): 12 mm; Свес (gs_trim_jambext_nosing_out): 50 mm; Выступ Вверху (gs_trimov_top_left_out): 100 mm; Выступ Вверху (gs_trimov_top_right_out): 100 mm; Ширина со Стороны 1 (gs_tw_right_in): 50 mm; Ширина со Стороны 2 (gs_tw_left_in): 50 mm; Ширина Вверху (gs_tw_top_in): 50 mm; Толщина по Стене (gs_trim_thk_in): 19 mm; Толщина в Проеме (gs_trim_width_in): 25 mm; Смещение (gs_trim_offs_in): 12 mm; Свес (gs_trim_jambext_nosing_in): 50 mm; Выступ Вверху (gs_trimov_top_left_in): 100 mm; Выступ Вверху (gs_trimov_top_right_in): 100 mm; Высота Порога: 12 mm; Ширина Порога: 10 mm; Внешняя Толщина Порога: 5.80738 mm; Выступ Порога Снаружи: 25 mm; Выступ Порога Внутри: 25 mm; Выступ Сбоку Снаружи: 0 mm; Выступ Сбоку Внутри: 0 mm; Высота Отлива: 25 mm; Высота Отлива Спереди: 15 mm; Зазор до Низа Проема: 5 mm; Наложение Отлива: 20 mm; Толщина Капельника: 30 mm; Свес Отлива: 30 mm; Свес Отлива со Стороны 1: 0 mm; Свес Отлива со Стороны 2: 0 mm; Сдвиг Отлива Вглубь: 20 mm; Ширина Верха Отлива: 10 mm; Высота Верха Отлива: 10 mm; Смещение Отлива от Стены: 0 mm; Зазор за Отливом (gs_sill_holeDepthBehind): 0 mm; Ширина Отлива: 0 mm; Толщина Кирпича (gs_brick_sill_br_thk): 65 mm; Толщина Раствора (gs_brick_sill_mort_thk): 15 mm; Ширина Доски: 100 mm; Толщина Доски: 25 mm; Выступ Доски: 30 mm; Выступ Доски Сбоку 1: 0 mm; Выступ Доски Сбоку 2: 0 mm; Смещение Подоконника Вглубь: 0 mm; Высота Клапана: 65 mm; Толщина Клапана: 110 mm; Высота Панели: 1500 mm; Смещение Внутрь: 20 mm; Глубина Отделки: 0 mm; Ширина Дополнительной Рамы: 40 mm; Толщина Дополнительной Рамы: 30 mm; Толщина Направляющей: 30 mm; Длина Стержня Подвеса: 20 mm; Радиус Стержня Подвеса: 5 mm; Расстояние до Панели: 6 mm; Наружный Выступ: 0 mm; Ширина Внутренней Панели: 120 mm; Ширина Открывания в 3D (gs_shutter_opLength): 1500 mm; Закрытая Часть в 3D (gs_shutter_closedLength): 0 mm; Ширина Открывания в 3D 1: 560 mm; Ширина Открывания в 3D 2: 140 mm; Высота Открывания в 3D: 1500 mm; Закрытая Часть в 3D (gs_shutter_closedHeight): 0 mm; Толщина Ставней: 50 mm; Ширина Обвязки Ставней: 50 mm; Ширина Коробки Внизу: 50 mm; Ширина Ставней: 0 mm; Толщина Заполнения Ставней: 10 mm; Толщина Ламелей: 10 mm; Ширина Ламелей: 40 mm; Ширина Доски Средника: 50 mm; Ширина Импостов: 50 mm; Радиус Отверстия: 10 mm; Ширина Вертикальных Досок: 100 mm; Ширина Z-профиля: 50 mm; Толщина Z-профиля: 25 mm; Толщина Вертикальных Досок: 25 mm; Толщина Горизонтальных Досок: 25 mm; Приблизительная Ширина Вертикальных Досок: 80 mm; Приблизительная Ширина Горизонтальных Досок: 115 mm; Высота Короба (gs_shutRoll_boxHeight): 200 mm; Глубина Короба (gs_shutRoll_boxWidth): 150 mm; Смещение Ставня Слева: 0 mm; Смещение Ставня Справа: 0 mm; Глубина Направляющей: 72.5 mm; Расстояние от Стены (gs_shutRoll_distFromWall): 0 mm; Расстояние от Перемычки (gs_shutRoll_distFromHead): 0 mm; Ширина Ламели: 50 mm; Высота Короба (gs_shutLam_boxHeight): 200 mm; Глубина Короба (gs_shutLam_boxWidth): 150 mm; Ширина Отлива Направляющей: 0 mm; Расстояние от Стены (gs_shutLam_distFromWall): 0 mm; Расстояние от Перемычки (gs_shutLam_distFromHead): 0 mm; Ширина Сегмента (gs_shutLam_segmentWidth): 60 mm; Высота Короба (gs_shutLam2_boxHeight): 60 mm; Ширина Ставня: 60 mm; Расстояние от Окна: 60 mm; Расстояние от Перемычки (gs_shutLam2_distFromHead): 60 mm; Высота Оси Ставня относительно Перемычки: 0 mm; Ширина Сегмента (gs_shutLam2_segmentWidth): 60 mm; Расстояние между Перемычкой и Дверью: 0 mm; Выступ Декоратовной Перемычки Сбоку 1: 0 mm; Выступ Декоратовной Перемычки Сбоку 2: 0 mm; Подъем Декоративной Перемычки: 30 mm; Проекция Декоративной Перемычки: 0 mm; Высота Декоративной Перемычки: 250 mm; Глубина Декоративной Перемычки: 120 mm; Зазор за Отливом (gs_masonry_arch_rearHoleDepth): 0 mm; Толщина Кирпича (gs_masonry_arch_brick_thk): 65 mm; Толщина Раствора (gs_masonry_arch_mort_thk): 10 mm; Ширина Замкового Камня: 100 mm; Выступ Замкового Камня: 0 mm; Проекция Замкового Камня: 10 mm; Глубина Четверти (gs_wido_sill): 0 mm; Глубина Четверти (AC_wido_sill): 0 mm; Ширина Четверти (gs_reveal_right): 60 mm; Ширина Четверти со Стороны 2: 60 mm; Ширина Боковой Нижней Четверти со Стороны 1: 60 mm; Ширина Боковой Нижней Четверти со Стороны 2: 60 mm; Ширина Внутренней Четверти со Стороны 2 (gs_reveal_splayed_innerLeft): 60 mm; Ширина Внутренней Четверти (gs_reveal_splayed_innerRight): 60 mm; Ширина Внутренней Четверти (gs_reveal_double_innerRight): 60 mm; Ширина Внутренней Четверти со Стороны 2 (gs_reveal_double_innerLeft): 60 mm; Ширина Нижней Внутренней Четверти со Стороны 1: 60 mm; Ширина Нижней Внутренней Четверти со Стороны 2: 60 mm; Ширина Верхней Четверти: 60 mm; Глубина Отлива: 60 mm; Глубина Отлива со Стороны 1: 60 mm; Глубина Отлива со Стороны 2: 60 mm; Глубина Внутренней Перемычки (gs_reveal_splayed_innerTop): 60 mm; Глубина Внутреннего Отлива (gs_reveal_splayed_innerBottom): 60 mm; Глубина Внутренней Перемычки (gs_reveal_double_innerTop): 60 mm; Глубина Внутреннего Отлива (gs_reveal_double_innerBottom): 60 mm; Глубина Внутреннего Отлива со Стороны 1: 0 mm; Глубина Внутреннего Отлива со Стороны 2: 0 mm; Ширина Наружной Четверти: 80 mm; Предел Толщины Штукатурки: 40 mm; Расстояние от Термовкладыша до Слоя: 0 mm; Ширина Термовкладыша: 38 mm; Толщина Термовкладыша: 100 mm; Толщина Вкладыша: 25 mm; Ширина Профиля: 150 mm; Специальная Толщина: 15 mm; Слой Выступает на Глубину Коробки: 0 mm; Допуск Проема Слева: 0 mm; Допуск Проема Справа: 0 mm; Допуск Проема Вверху: 0 mm; Допуск Проема Внизу: 0 mm; Ширина Открывания в 3D (gs_open3D): 0 mm; Ширина Открывания в 3D со Стороны 2: 0 mm; Ширина Открывания в 2D: 0 mm; Ширина Открывания в 2D со Стороны 2: 0 mm; Ширина Открывания 1 Основной Боковой Створки 1: 0 mm; Ширина Открывания 2 Основной Боковой Створки 1: 0 mm; Ширина Открывания 1 Основной Боковой Створки 2: 0 mm; Ширина Открывания 2 Основной Боковой Створки 2: 0 mm; Ширина Открывания 1 Средней Фрамуги: 0 mm; Ширина Открывания 2 Средней Фрамуги: 0 mm; Ширина Открывания 1 Боковой Фрамуги 1: 0 mm; Ширина Открывания 2 Боковой Фрамуги 1: 0 mm; Ширина Открывания 1 Боковой Фрамуги 2: 0 mm; Ширина Открывания 2 Боковой Фрамуги 2: 0 mm; Ширина 2 со Стороны Открывания: 300 mm; Ширина 1 со Стороны Открывания: 100 mm; Глубина со Стороны Открывания: 1800 mm; Ширина 2 с Противоположной Стороны: 250 mm; Ширина 1 с Противоположной Стороны: 100 mm; Глубина с Противоположной Стороны: 1200 mm; AC Допуск Проема Слева: 0 mm; AC Допуск Проема Справа: 0 mm; AC Допуск Проема Вверху: 0 mm; AC Допуск Проема Внизу: 0 mm; Реальная Толщина Коробки: 115 mm

# IfcWallStandardCase: Общая Конструкция Стены/Оболочки 300 (4)
In: 1-й этаж
Classification: Стена (Классификация ARCHICAD); Material: ОБЩИЙ - НАРУЖНАЯ ОТДЕЛКА 50 mm, ОБЩИЙ - КОНСТРУКТИВНЫЙ 250 mm
Pset_ConcreteElementGeneral - EnvironmentalClass: 0; FireRating: Не определено; ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0; ConstructionType: Не определено
Pset_WallCommon - AcousticRating: 25; FireRating: Не определено; Combustible: no; ThermalTransmittance: 0; LoadBearing: yes; IsExternal: yes
Pset_FireRatingProperties - FireResistanceRating: Не определено; IsCombustible: no
ArchiCADProperties - Cлой: Конструктив - Стены Несущие; Строительный Материал / Многослойная / Профиль / Штриховка: Общая Конструкция Стены/Оболочки; Заблокирован: no; Собственный Этаж: 1-й этаж; Тип: Стена; Абсолютный Этаж Верхней Привязки: 2-й этаж; Относительный Этаж Верхней Привязки: Собственный + 1; Этаж Верхней Привязки: Собственный + 1 (2-й этаж); Тип Конструкции: Многослойная; Строительные Материалы (Все): ОБЩИЙ - НАРУЖНАЯ ОТДЕЛКА; ОБЩИЙ - КОНСТРУКТИВНЫЙ; Расположение: Снаружи; Статус Реконструкции: Существующий; Конструктивная Функция: Несущий Элемент; Показ в Фильтре Реконструкции: Все Релевантные Фильтры; Тип Наклона Стены: Вертикальная; Геометрический Вариант: Одинаковые; Расположение Линии Привязки: Наружная Поверхность; Покрытие Внутренней Поверхности: Краска - Светло-Серая; Покрытие Наружной Поверхности: Краска - Песочно-Бежевая; Угол Наклона Внутренней Поверхности Стены: 5156.62 deg; Угол Наклона Наружной Поверхности Стены: 5156.62 deg; Классификация ARCHICAD - 21: Стена
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
ArchiCADQuantities - Высота: 3000 mm; Ширина: 300 mm; Отметка относительно Нуля Проекта: -100 mm; Отметка отн. 1-й уровень привязки: 50 mm; Отметка отн. 2-й уровень привязки: -3400 mm; Отметка отн. Уровня Моря: -100 mm; Отметка относительно Этажа: -100 mm; Смещение Основания: -100 mm; Смещение Верха: -100 mm; Толщина: 300 mm; Количество Отверстий (Количество Пустых Проемов): 0; Количество Окон: 0; Количество Колонн: 0; Объем Колонн: 0 m3; Максимальная Высота Слоя с Внутренней Стороны Стены: 3000 mm; Максимальная Высота Стены: 3000 mm; Максимальная Высота Слоя с Наружной Стороны Стены: 3000 mm; Толщина Воздушной Прослойки: 0 mm; Толщина Слоя с Внутренней Стороны Стены: 250 mm; Толщина Слоя Изоляции: 0 mm; Толщина Слоя с Наружной Стороны Стены: 50 mm; Площадь Окон: 0 m2; Общая Ширина Окон: 0 mm; Толщина Стены: 300 mm; Толщина Стены в Конце: 300 mm; Площадь Пустых Проемов в Стене: 0 m2
Name | ID Элемента = Связь и ID Элемента = Родительский ID | Покрытия (Все) | Площадь (m2) = Площадь Стены (m2) | Чистый Объем (m3) | Площадь Поверхности (m2) = Чистая Площадь Наружной Поверхности (m2) | 3D-длина (mm) | Количество Дверей | Минимальная Высота Слоя с Внутренней Стороны Стены (mm) = Минимальная Высота Стены (mm) = Минимальная Высота Слоя с Наружной Стороны Стены (mm) | Площадь Дверей (m2) = Аналитическая Площадь Проемов с Внутренней Стороны (m2) = Аналитическая Площадь Проемов с Наружной Стороны (m2) | Общая Ширина Дверей (mm) | Объем Слоя c Внутренней Стороны Стены (m3) | Объем Слоя c Наружной Стороны Стены (m3) | Средняя длина Стены (mm) = Длина Стены по Центру (mm) | Чистая Площадь Поверхности Торцов (m2) | Чистая Площадь Внутренней Поверхности (m2) | Аналитический Объем Проемов (m3) | Длина Линии Привязки (mm) | Условная Длина по Внутренней Стороне (mm) = Длина Стены по Внутренней Стороне (mm) | Условная Площадь Поверхности с Внутренней Стороны (m2) | Условная Длина по Наружной Стороне (mm) = Длина Стены по Наружной Стороне (mm) | Условная Площадь Поверхности с Наружной Стороны (m2) | Условный Объем Слоя c Внутренней Стороны Стены (m3) | Условный Объем Слоя c Наружной Стороны Стены (m3) | Условный Объем (m3) | Общая Площадь Внутренней Поверхности Стены (m2) = Общая Площадь Наружной Поверхности Стены (m2) | Общий Объем Стены (m3) | Периметр Стены (mm)
СТН-002 | СТН-002 | Краска - Светло-Серая; Краска - Песочно-Бежевая | 7.27686 | 21.9281 | 73.2186 | 24406.2 | 0 | 0 | 0 | 0 | 18.2672 | 3.66093 | 24256.2 | 15.5187 | 73.0686 | 0 | 24406.2 | 24106.2 | 73.0686 | 24406.2 | 73.2186 | 18.2672 | 3.66093 | 21.9281 | 73.2186 | 21.9656 | 49236.7
СТН-003 | СТН-003 | Краска - Песочно-Бежевая; Краска - Светло-Серая | 9.52319 | 28.0026 | 93.3419 | 31744 | 1 | 3000 | 1.89 | 900 | 23.3355 | 4.66709 | 31744 | 20.8464 | 93.3419 | 0.567 | 31744 | 31744 | 95.2319 | 31744 | 95.2319 | 23.808 | 4.76159 | 28.5696 | 95.2319 | 28.5696 | 64087.9
СТН-004 | СТН-004 | Краска - Светло-Серая; Краска - Песочно-Бежевая | 7.28401 | 21.852 | 72.8401 | 24280 | 0 | 3000 | 0 | 0 | 18.21 | 3.64201 | 24280 | 16.368 | 72.8401 | 0 | 24280 | 24280 | 72.8401 | 24280 | 72.8401 | 18.21 | 3.64201 | 21.852 | 72.8401 | 21.852 | 49160.1
СТН-005 | СТН-005 | Краска - Светло-Серая; Краска - Песочно-Бежевая | 9.465 | 28.2975 | 94.95 | 31650 | 0 | 0 | 0 | 0 | 23.55 | 4.7475 | 31550 | 18.865 | 94.2 | 0 | 32000 | 31400 | 94.2 | 31700 | 94.95 | 23.55 | 4.7475 | 28.2975 | 96 | 28.8 | 63824.3
