Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: C:\\DEV\\tiemens\\basic_tests\\Roof_01 2x3\\def_dwg\\D-80336 Munich, Matthias-Pschorr-Strasse.ifc
Time: 2016-09-21T08:27:29
Author: Bricsys
Organization: Bricsys
Written by: BricsCAD BIM
Made in: BricsCAD BIM
Authorization: BricsCAD BIM

# IfcSite, D-80336 Munich, Matthias-Pschorr-Strasse
RefLatitude: 37, 47, 42; RefLongitude: 122, 23, 38

# IfcBuilding, Roof structure
ElevationOfRefHeight: 0 m; ElevationOfTerrain: 0 m

# IfcBuildingStorey (2)
In: Roof structure
Name | Elevation (m)
Level 0 | 0
Level 1 | 4

# IfcRoof (8)
Pset_RoofCommon - IsExternal: no; ProjectedArea: 0 m2; TotalArea: 0 m2
Name | In | Material
roof_04 | Level 0 | Wood
roof_03 | Level 0 | Wood
roof_05 | Level 0 | Wood
roof_06 | Level 0 | Wood
roof_01 | Level 0
roof_02_a | Level 1 | Wood
roof_02_c | Level 1 | Aluminium
roof_02_b | Level 1 | Aluminium

# IfcSlab: wood 0.4 (6)
In: Level 0
Type - PredefinedType: FLOOR; Material: Wood 0.0004 m
PredefinedType: ROOF
Pset_SlabCommon - Combustible: no; ThermalTransmittance: 0; IsExternal: no; LoadBearing: yes; Compartmentation: no; PitchAngle: 0 rad
Name
roof_01_c
roof_01_b
roof_01_a
roof_01_f
roof_01_d
roof_01_e

# IfcWall: Single layer wall (2)
In: Level 0
Type - PredefinedType: STANDARD; Material: Concrete, Reinforced 0.3 m
Pset_WallCommon - Combustible: no; ThermalTransmittance: 0; IsExternal: no; ExtendToStructure: yes; LoadBearing: no; Compartmentation: no
Name
wall_10
wall_07

# IfcWallStandardCase: Single layer wall (8)
Type - PredefinedType: STANDARD; Material: Concrete, Reinforced 0.3 m
Pset_WallCommon - Combustible: no; ThermalTransmittance: 0; IsExternal: no; ExtendToStructure: yes; LoadBearing: no; Compartmentation: no
Name | In
wall_02 | Level 0
wall_04 | Level 0
wall_06 | Level 1
wall_05 | Level 1
wall_08 | Level 0
wall_09 | Level 0
wall_03 | Level 0
wall_01 | Level 0

# IfcWindow: standard-window-1p, Window01
In: Level 1
Type - ConstructionType: WOOD; OperationType: SINGLE_PANEL; ParameterTakesPrecedence: no; Sizeable: no
Type - IfcWindowPanelProperties - OperationType: TOPHUNG; PanelPosition: LEFT
OverallHeight: 1.9 m; OverallWidth: 3.07 m
Pset_WindowCommon - ThermalTransmittance: 0; IsExternal: yes; Infiltration: 0; SmokeStop: no
Pset_DoorWindowGlazingType - GlassLayers: 0; IsTempered: no; IsLaminated: no; IsCoated: no; IsWired: no; Translucency: 1; ThermalTransmittanceSummer: 0; ThermalTransmittanceWinter: 0
